# Repository alexiosc/cft (continued)

## KiCad design kicad/cft/cft-backplane/cft-backplane.kicad_pcb (continued)

Parts:
H1, H2: MountingHole_Pad; MountingHole_2.7mm_M2.5_ISO14580_Pad
J5: DIN-41612-3x32-Bauform-C; DIN41612_C_3x32_Female_Vertical_THT

Connections:
+5V: J5.A1, J5.B1, J5.C1; also elsewhere on the board
/A3: J5.A3; also elsewhere on the board
/A15: J5.A15; also elsewhere on the board
/A16: J5.A16; also elsewhere on the board
/A17: J5.A17; also elsewhere on the board
/A18: J5.A18; also elsewhere on the board
/A19: J5.A19; also elsewhere on the board
/A20: J5.A20; also elsewhere on the board
/A21: J5.A21; also elsewhere on the board
/A22: J5.A22; also elsewhere on the board
/A23: J5.A23; also elsewhere on the board
/A24: J5.A24; also elsewhere on the board
/A25: J5.A25; also elsewhere on the board
/A26: J5.A26; also elsewhere on the board
/A27: J5.A27; also elsewhere on the board
/A28: J5.A28; also elsewhere on the board
/A29: J5.A29; also elsewhere on the board
/A30: J5.A30; also elsewhere on the board
/B6: J5.B6; also elsewhere on the board
/B7: J5.B7; also elsewhere on the board
/B8: J5.B8; also elsewhere on the board
/B9: J5.B9; also elsewhere on the board
/B10: J5.B10; also elsewhere on the board
/B11: J5.B11; also elsewhere on the board
/B12: J5.B12; also elsewhere on the board
/B13: J5.B13; also elsewhere on the board
/B14: J5.B14; also elsewhere on the board
/B15: J5.B15; also elsewhere on the board
/B16: J5.B16; also elsewhere on the board
/B17: J5.B17; also elsewhere on the board
/B18: J5.B18; also elsewhere on the board
/B19: J5.B19; also elsewhere on the board
/B20: J5.B20; also elsewhere on the board
/B21: J5.B21; also elsewhere on the board
/B22: J5.B22; also elsewhere on the board
/B23: J5.B23; also elsewhere on the board
/B24: J5.B24; also elsewhere on the board
/B25: J5.B25; also elsewhere on the board
/B26: J5.B26; also elsewhere on the board
/B27: J5.B27; also elsewhere on the board
/B28: J5.B28; also elsewhere on the board
/B29: J5.B29; also elsewhere on the board
/B30: J5.B30; also elsewhere on the board
/C4: J5.C4; also elsewhere on the board
/C5: J5.C5; also elsewhere on the board
/C6: J5.C6; also elsewhere on the board
/C7: J5.C7; also elsewhere on the board
/C8: J5.C8; also elsewhere on the board
/C9: J5.C9; also elsewhere on the board
/C10: J5.C10; also elsewhere on the board
/C11: J5.C11; also elsewhere on the board
/C12: J5.C12; also elsewhere on the board
/C13: J5.C13; also elsewhere on the board
/C14: J5.C14; also elsewhere on the board
/C15: J5.C15; also elsewhere on the board
/C16: J5.C16; also elsewhere on the board
/C17: J5.C17; also elsewhere on the board
/C18: J5.C18; also elsewhere on the board
/C19: J5.C19; also elsewhere on the board
/C20: J5.C20; also elsewhere on the board
/C21: J5.C21; also elsewhere on the board
/C22: J5.C22; also elsewhere on the board
/C23: J5.C23; also elsewhere on the board
/C24: J5.C24; also elsewhere on the board
/C25: J5.C25; also elsewhere on the board
/C26: J5.C26; also elsewhere on the board
/C27: J5.C27; also elsewhere on the board
/C28: J5.C28; also elsewhere on the board
/C29: J5.C29; also elsewhere on the board
/C30: J5.C30; also elsewhere on the board
/Sheet6199673A/A2: J5.A2; also elsewhere on the board
/Sheet6199673A/A4: J5.A4; also elsewhere on the board
/Sheet6199673A/A5: J5.A5; also elsewhere on the board
/Sheet6199673A/A6: J5.A6; also elsewhere on the board
/Sheet6199673A/A7: J5.A7; also elsewhere on the board
/Sheet6199673A/A8: J5.A8; also elsewhere on the board
/Sheet6199673A/A9: J5.A9; also elsewhere on the board
/Sheet6199673A/A10: J5.A10; also elsewhere on the board
/Sheet6199673A/A11: J5.A11; also elsewhere on the board
/Sheet6199673A/A12: J5.A12; also elsewhere on the board
/Sheet6199673A/A13: J5.A13; also elsewhere on the board
/Sheet6199673A/A14: J5.A14; also elsewhere on the board
/Sheet6199673A/B2: J5.B2; also elsewhere on the board
/Sheet6199673A/B3: J5.B3; also elsewhere on the board
/Sheet6199673A/B4: J5.B4; also elsewhere on the board
/Sheet6199673A/B5: J5.B5; also elsewhere on the board
/Sheet6199673A/C2: J5.C2; also elsewhere on the board
/Sheet6199673A/C3: J5.C3; also elsewhere on the board
GND: H1.1, H2.1, J5.A31, J5.A32, J5.B31, J5.B32, J5.C31, J5.C32; also elsewhere on the board

Parts of its further copies:
H3, H4, H5, H6, H7, H8, H9, H10, H11, H12, H13, H14, H15, H16, H17, H18, H19, H20, H21, H22, H23, H24: MountingHole_Pad; MountingHole_2.7mm_M2.5_ISO14580_Pad
J1, J2, J3, J4, J6, J7, J8, J9, J10, J11, J12: DIN-41612-3x32-Bauform-C; DIN41612_C_3x32_Female_Vertical_THT

Connections of its further copies:
+5V: J1.A1, J1.B1, J1.C1, J2.A1, J2.B1, J2.C1, J3.A1, J3.B1, J3.C1, J4.A1, J4.B1, J4.C1, J6.A1, J6.B1, J6.C1, J7.A1, J7.B1, J7.C1, J8.A1, J8.B1, J8.C1, J9.A1, J9.B1, J9.C1, J10.A1, J10.B1, J10.C1, J11.A1, J11.B1, J11.C1, J12.A1, J12.B1, J12.C1; also elsewhere on the board
/A3: J1.A3, J2.A3, J3.A3, J4.A3, J6.A3, J7.A3, J8.A3, J9.A3, J10.A3, J11.A3, J12.A3; also elsewhere on the board
/A15: J1.A15, J2.A15, J3.A15, J4.A15, J6.A15, J7.A15, J8.A15, J9.A15, J10.A15, J11.A15, J12.A15; also elsewhere on the board
/A16: J1.A16, J2.A16, J3.A16, J4.A16, J6.A16, J7.A16, J8.A16, J9.A16, J10.A16, J11.A16, J12.A16; also elsewhere on the board
/A17: J1.A17, J2.A17, J3.A17, J4.A17, J6.A17, J7.A17, J8.A17, J9.A17, J10.A17, J11.A17, J12.A17; also elsewhere on the board
/A18: J1.A18, J2.A18, J3.A18, J4.A18, J6.A18, J7.A18, J8.A18, J9.A18, J10.A18, J11.A18, J12.A18; also elsewhere on the board
/A19: J1.A19, J2.A19, J3.A19, J4.A19, J6.A19, J7.A19, J8.A19, J9.A19, J10.A19, J11.A19, J12.A19; also elsewhere on the board
/A20: J1.A20, J2.A20, J3.A20, J4.A20, J6.A20, J7.A20, J8.A20, J9.A20, J10.A20, J11.A20, J12.A20; also elsewhere on the board
/A21: J1.A21, J2.A21, J3.A21, J4.A21, J6.A21, J7.A21, J8.A21, J9.A21, J10.A21, J11.A21, J12.A21; also elsewhere on the board
/A22: J1.A22, J2.A22, J3.A22, J4.A22, J6.A22, J7.A22, J8.A22, J9.A22, J10.A22, J11.A22, J12.A22; also elsewhere on the board
/A23: J1.A23, J2.A23, J3.A23, J4.A23, J6.A23, J7.A23, J8.A23, J9.A23, J10.A23, J11.A23, J12.A23; also elsewhere on the board
/A24: J1.A24, J2.A24, J3.A24, J4.A24, J6.A24, J7.A24, J8.A24, J9.A24, J10.A24, J11.A24, J12.A24; also elsewhere on the board
/A25: J1.A25, J2.A25, J3.A25, J4.A25, J6.A25, J7.A25, J8.A25, J9.A25, J10.A25, J11.A25, J12.A25; also elsewhere on the board
/A26: J1.A26, J2.A26, J3.A26, J4.A26, J6.A26, J7.A26, J8.A26, J9.A26, J10.A26, J11.A26, J12.A26; also elsewhere on the board
/A27: J1.A27, J2.A27, J3.A27, J4.A27, J6.A27, J7.A27, J8.A27, J9.A27, J10.A27, J11.A27, J12.A27; also elsewhere on the board
/A28: J1.A28, J2.A28, J3.A28, J4.A28, J6.A28, J7.A28, J8.A28, J9.A28, J10.A28, J11.A28, J12.A28; also elsewhere on the board
/A29: J1.A29, J2.A29, J3.A29, J4.A29, J6.A29, J7.A29, J8.A29, J9.A29, J10.A29, J11.A29, J12.A29; also elsewhere on the board
/A30: J1.A30, J2.A30, J3.A30, J4.A30, J6.A30, J7.A30, J8.A30, J9.A30, J10.A30, J11.A30, J12.A30; also elsewhere on the board
/B6: J1.B6, J2.B6, J3.B6, J4.B6, J6.B6, J7.B6, J8.B6, J9.B6, J10.B6, J11.B6, J12.B6; also elsewhere on the board
/B7: J1.B7, J2.B7, J3.B7, J4.B7, J6.B7, J7.B7, J8.B7, J9.B7, J10.B7, J11.B7, J12.B7; also elsewhere on the board
/B8: J1.B8, J2.B8, J3.B8, J4.B8, J6.B8, J7.B8, J8.B8, J9.B8, J10.B8, J11.B8, J12.B8; also elsewhere on the board
/B9: J1.B9, J2.B9, J3.B9, J4.B9, J6.B9, J7.B9, J8.B9, J9.B9, J10.B9, J11.B9, J12.B9; also elsewhere on the board
/B10: J1.B10, J2.B10, J3.B10, J4.B10, J6.B10, J7.B10, J8.B10, J9.B10, J10.B10, J11.B10, J12.B10; also elsewhere on the board
/B11: J1.B11, J2.B11, J3.B11, J4.B11, J6.B11, J7.B11, J8.B11, J9.B11, J10.B11, J11.B11, J12.B11; also elsewhere on the board
/B12: J1.B12, J2.B12, J3.B12, J4.B12, J6.B12, J7.B12, J8.B12, J9.B12, J10.B12, J11.B12, J12.B12; also elsewhere on the board
/B13: J1.B13, J2.B13, J3.B13, J4.B13, J6.B13, J7.B13, J8.B13, J9.B13, J10.B13, J11.B13, J12.B13; also elsewhere on the board
/B14: J1.B14, J2.B14, J3.B14, J4.B14, J6.B14, J7.B14, J8.B14, J9.B14, J10.B14, J11.B14, J12.B14; also elsewhere on the board
/B15: J1.B15, J2.B15, J3.B15, J4.B15, J6.B15, J7.B15, J8.B15, J9.B15, J10.B15, J11.B15, J12.B15; also elsewhere on the board
/B16: J1.B16, J2.B16, J3.B16, J4.B16, J6.B16, J7.B16, J8.B16, J9.B16, J10.B16, J11.B16, J12.B16; also elsewhere on the board
/B17: J1.B17, J2.B17, J3.B17, J4.B17, J6.B17, J7.B17, J8.B17, J9.B17, J10.B17, J11.B17, J12.B17; also elsewhere on the board
/B18: J1.B18, J2.B18, J3.B18, J4.B18, J6.B18, J7.B18, J8.B18, J9.B18, J10.B18, J11.B18, J12.B18; also elsewhere on the board
/B19: J1.B19, J2.B19, J3.B19, J4.B19, J6.B19, J7.B19, J8.B19, J9.B19, J10.B19, J11.B19, J12.B19; also elsewhere on the board
/B20: J1.B20, J2.B20, J3.B20, J4.B20, J6.B20, J7.B20, J8.B20, J9.B20, J10.B20, J11.B20, J12.B20; also elsewhere on the board
/B21: J1.B21, J2.B21, J3.B21, J4.B21, J6.B21, J7.B21, J8.B21, J9.B21, J10.B21, J11.B21, J12.B21; also elsewhere on the board
/B22: J1.B22, J2.B22, J3.B22, J4.B22, J6.B22, J7.B22, J8.B22, J9.B22, J10.B22, J11.B22, J12.B22; also elsewhere on the board
/B23: J1.B23, J2.B23, J3.B23, J4.B23, J6.B23, J7.B23, J8.B23, J9.B23, J10.B23, J11.B23, J12.B23; also elsewhere on the board
/B24: J1.B24, J2.B24, J3.B24, J4.B24, J6.B24, J7.B24, J8.B24, J9.B24, J10.B24, J11.B24, J12.B24; also elsewhere on the board
/B25: J1.B25, J2.B25, J3.B25, J4.B25, J6.B25, J7.B25, J8.B25, J9.B25, J10.B25, J11.B25, J12.B25; also elsewhere on the board
/B26: J1.B26, J2.B26, J3.B26, J4.B26, J6.B26, J7.B26, J8.B26, J9.B26, J10.B26, J11.B26, J12.B26; also elsewhere on the board
/B27: J1.B27, J2.B27, J3.B27, J4.B27, J6.B27, J7.B27, J8.B27, J9.B27, J10.B27, J11.B27, J12.B27; also elsewhere on the board
/B28: J1.B28, J2.B28, J3.B28, J4.B28, J6.B28, J7.B28, J8.B28, J9.B28, J10.B28, J11.B28, J12.B28; also elsewhere on the board
/B29: J1.B29, J2.B29, J3.B29, J4.B29, J6.B29, J7.B29, J8.B29, J9.B29, J10.B29, J11.B29, J12.B29; also elsewhere on the board
/B30: J1.B30, J2.B30, J3.B30, J4.B30, J6.B30, J7.B30, J8.B30, J9.B30, J10.B30, J11.B30, J12.B30; also elsewhere on the board
/C4: J1.C4, J2.C4, J3.C4, J4.C4, J6.C4, J7.C4, J8.C4, J9.C4, J10.C4, J11.C4, J12.C4; also elsewhere on the board
/C5: J1.C5, J2.C5, J3.C5, J4.C5, J6.C5, J7.C5, J8.C5, J9.C5, J10.C5, J11.C5, J12.C5; also elsewhere on the board
/C6: J1.C6, J2.C6, J3.C6, J4.C6, J6.C6, J7.C6, J8.C6, J9.C6, J10.C6, J11.C6, J12.C6; also elsewhere on the board
/C7: J1.C7, J2.C7, J3.C7, J4.C7, J6.C7, J7.C7, J8.C7, J9.C7, J10.C7, J11.C7, J12.C7; also elsewhere on the board
/C8: J1.C8, J2.C8, J3.C8, J4.C8, J6.C8, J7.C8, J8.C8, J9.C8, J10.C8, J11.C8, J12.C8; also elsewhere on the board
/C9: J1.C9, J2.C9, J3.C9, J4.C9, J6.C9, J7.C9, J8.C9, J9.C9, J10.C9, J11.C9, J12.C9; also elsewhere on the board
/C10: J1.C10, J2.C10, J3.C10, J4.C10, J6.C10, J7.C10, J8.C10, J9.C10, J10.C10, J11.C10, J12.C10; also elsewhere on the board
/C11: J1.C11, J2.C11, J3.C11, J4.C11, J6.C11, J7.C11, J8.C11, J9.C11, J10.C11, J11.C11, J12.C11; also elsewhere on the board
/C12: J1.C12, J2.C12, J3.C12, J4.C12, J6.C12, J7.C12, J8.C12, J9.C12, J10.C12, J11.C12, J12.C12; also elsewhere on the board
/C13: J1.C13, J2.C13, J3.C13, J4.C13, J6.C13, J7.C13, J8.C13, J9.C13, J10.C13, J11.C13, J12.C13; also elsewhere on the board
/C14: J1.C14, J2.C14, J3.C14, J4.C14, J6.C14, J7.C14, J8.C14, J9.C14, J10.C14, J11.C14, J12.C14; also elsewhere on the board
/C15: J1.C15, J2.C15, J3.C15, J4.C15, J6.C15, J7.C15, J8.C15, J9.C15, J10.C15, J11.C15, J12.C15; also elsewhere on the board
/C16: J1.C16, J2.C16, J3.C16, J4.C16, J6.C16, J7.C16, J8.C16, J9.C16, J10.C16, J11.C16, J12.C16; also elsewhere on the board
/C17: J1.C17, J2.C17, J3.C17, J4.C17, J6.C17, J7.C17, J8.C17, J9.C17, J10.C17, J11.C17, J12.C17; also elsewhere on the board
/C18: J1.C18, J2.C18, J3.C18, J4.C18, J6.C18, J7.C18, J8.C18, J9.C18, J10.C18, J11.C18, J12.C18; also elsewhere on the board
/C19: J1.C19, J2.C19, J3.C19, J4.C19, J6.C19, J7.C19, J8.C19, J9.C19, J10.C19, J11.C19, J12.C19; also elsewhere on the board
/C20: J1.C20, J2.C20, J3.C20, J4.C20, J6.C20, J7.C20, J8.C20, J9.C20, J10.C20, J11.C20, J12.C20; also elsewhere on the board
/C21: J1.C21, J2.C21, J3.C21, J4.C21, J6.C21, J7.C21, J8.C21, J9.C21, J10.C21, J11.C21, J12.C21; also elsewhere on the board
/C22: J1.C22, J2.C22, J3.C22, J4.C22, J6.C22, J7.C22, J8.C22, J9.C22, J10.C22, J11.C22, J12.C22; also elsewhere on the board
/C23: J1.C23, J2.C23, J3.C23, J4.C23, J6.C23, J7.C23, J8.C23, J9.C23, J10.C23, J11.C23, J12.C23; also elsewhere on the board
/C24: J1.C24, J2.C24, J3.C24, J4.C24, J6.C24, J7.C24, J8.C24, J9.C24, J10.C24, J11.C24, J12.C24; also elsewhere on the board
/C25: J1.C25, J2.C25, J3.C25, J4.C25, J6.C25, J7.C25, J8.C25, J9.C25, J10.C25, J11.C25, J12.C25; also elsewhere on the board
/C26: J1.C26, J2.C26, J3.C26, J4.C26, J6.C26, J7.C26, J8.C26, J9.C26, J10.C26, J11.C26, J12.C26; also elsewhere on the board
/C27: J1.C27, J2.C27, J3.C27, J4.C27, J6.C27, J7.C27, J8.C27, J9.C27, J10.C27, J11.C27, J12.C27; also elsewhere on the board
/C28: J1.C28, J2.C28, J3.C28, J4.C28, J6.C28, J7.C28, J8.C28, J9.C28, J10.C28, J11.C28, J12.C28; also elsewhere on the board
/C29: J1.C29, J2.C29, J3.C29, J4.C29, J6.C29, J7.C29, J8.C29, J9.C29, J10.C29, J11.C29, J12.C29; also elsewhere on the board
/C30: J1.C30, J2.C30, J3.C30, J4.C30, J6.C30, J7.C30, J8.C30, J9.C30, J10.C30, J11.C30, J12.C30; also elsewhere on the board
/Sheet6199673A/A2: J1.A2, J2.A2, J3.A2, J4.A2, J6.A2, J7.A2, J8.A2, J9.A2, J10.A2, J11.A2, J12.A2; also elsewhere on the board
/Sheet6199673A/A4: J1.A4, J2.A4, J3.A4, J4.A4, J6.A4, J7.A4, J8.A4, J9.A4, J10.A4, J11.A4, J12.A4; also elsewhere on the board
/Sheet6199673A/A5: J1.A5, J2.A5, J3.A5, J4.A5, J6.A5, J7.A5, J8.A5, J9.A5, J10.A5, J11.A5, J12.A5; also elsewhere on the board
/Sheet6199673A/A6: J1.A6, J2.A6, J3.A6, J4.A6, J6.A6, J7.A6, J8.A6, J9.A6, J10.A6, J11.A6, J12.A6; also elsewhere on the board
/Sheet6199673A/A7: J1.A7, J2.A7, J3.A7, J4.A7, J6.A7, J7.A7, J8.A7, J9.A7, J10.A7, J11.A7, J12.A7; also elsewhere on the board
/Sheet6199673A/A8: J1.A8, J2.A8, J3.A8, J4.A8, J6.A8, J7.A8, J8.A8, J9.A8, J10.A8, J11.A8, J12.A8; also elsewhere on the board
/Sheet6199673A/A9: J1.A9, J2.A9, J3.A9, J4.A9, J6.A9, J7.A9, J8.A9, J9.A9, J10.A9, J11.A9, J12.A9; also elsewhere on the board
/Sheet6199673A/A10: J1.A10, J2.A10, J3.A10, J4.A10, J6.A10, J7.A10, J8.A10, J9.A10, J10.A10, J11.A10, J12.A10; also elsewhere on the board
/Sheet6199673A/A11: J1.A11, J2.A11, J3.A11, J4.A11, J6.A11, J7.A11, J8.A11, J9.A11, J10.A11, J11.A11, J12.A11; also elsewhere on the board
/Sheet6199673A/A12: J1.A12, J2.A12, J3.A12, J4.A12, J6.A12, J7.A12, J8.A12, J9.A12, J10.A12, J11.A12, J12.A12; also elsewhere on the board
/Sheet6199673A/A13: J1.A13, J2.A13, J3.A13, J4.A13, J6.A13, J7.A13, J8.A13, J9.A13, J10.A13, J11.A13, J12.A13; also elsewhere on the board
/Sheet6199673A/A14: J1.A14, J2.A14, J3.A14, J4.A14, J6.A14, J7.A14, J8.A14, J9.A14, J10.A14, J11.A14, J12.A14; also elsewhere on the board
/Sheet6199673A/B2: J1.B2, J2.B2, J3.B2, J4.B2, J6.B2, J7.B2, J8.B2, J9.B2, J10.B2, J11.B2, J12.B2; also elsewhere on the board
/Sheet6199673A/B3: J1.B3, J2.B3, J3.B3, J4.B3, J6.B3, J7.B3, J8.B3, J9.B3, J10.B3, J11.B3, J12.B3; also elsewhere on the board
/Sheet6199673A/B4: J1.B4, J2.B4, J3.B4, J4.B4, J6.B4, J7.B4, J8.B4, J9.B4, J10.B4, J11.B4, J12.B4; also elsewhere on the board
/Sheet6199673A/B5: J1.B5, J2.B5, J3.B5, J4.B5, J6.B5, J7.B5, J8.B5, J9.B5, J10.B5, J11.B5, J12.B5; also elsewhere on the board
/Sheet6199673A/C2: J1.C2, J2.C2, J3.C2, J4.C2, J6.C2, J7.C2, J8.C2, J9.C2, J10.C2, J11.C2, J12.C2; also elsewhere on the board
/Sheet6199673A/C3: J1.C3, J2.C3, J3.C3, J4.C3, J6.C3, J7.C3, J8.C3, J9.C3, J10.C3, J11.C3, J12.C3; also elsewhere on the board
GND: H3.1, H4.1, H5.1, H6.1, H7.1, H8.1, H9.1, H10.1, H11.1, H12.1, H13.1, H14.1, H15.1, H16.1, H17.1, H18.1, H19.1, H20.1, H21.1, H22.1, H23.1, H24.1, J1.A31, J1.A32, J1.B31, J1.B32, J1.C31, J1.C32, J2.A31, J2.A32, J2.B31, J2.B32, J2.C31, J2.C32, J3.A31, J3.A32, J3.B31, J3.B32, J3.C31, J3.C32, J4.A31, J4.A32, J4.B31, J4.B32, J4.C31, J4.C32, J6.A31, J6.A32, J6.B31, J6.B32, J6.C31, J6.C32, J7.A31, J7.A32, J7.B31, J7.B32, J7.C31, J7.C32, J8.A31, J8.A32, J8.B31, J8.B32, J8.C31, J8.C32, J9.A31, J9.A32, J9.B31, J9.B32, J9.C31, J9.C32, J10.A31, J10.A32, J10.B31, J10.B32, J10.C31, J10.C32, J11.A31, J11.A32, J11.B31, J11.B32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; also elsewhere on the board

Board: 2 copper layers, 300.3 x 128.6 mm, 76 parts (15 on the bottom side), 97 nets.

Other parts of the board:
C17: 100nF; C_SMD_0805_2012Metric_Pad1.15x1.40mm_HandSolder
H23#2, H23#3, H24#2, H24#3: MountingHole_Pad; MountingHole_2.7mm_M2.5_ISO14580_Pad
U7: SN74ACT1071; SOIC-14

Their connections:
+5V: C17.1, U7.10, U7.11; also elsewhere on the board
/A15: U7.14; also elsewhere on the board
/A16: U7.1; also elsewhere on the board
/A17: U7.13; also elsewhere on the board
/A18: U7.2; also elsewhere on the board
/A19: U7.12; also elsewhere on the board
/A20: U7.5; also elsewhere on the board
/A21: U7.6; also elsewhere on the board
/A22: U7.7; also elsewhere on the board
/A23: U7.9; also elsewhere on the board
/A24: U7.8; also elsewhere on the board
GND: C17.2, H23#2.1, H23#3.1, H24#2.1, H24#3.1, U7.3, U7.4; also elsewhere on the board

## KiCad design kicad/cft/cft-dfp-pod/cft-dfp-pod.kicad_pcb

Board: 2 copper layers, 50.8 x 43.2 mm, 23 parts (8 on the bottom side), 51 nets.

Parts:
C1, C2, C3, C4, C5: 100nF; SMD_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C6, C7: 1uF; SMD_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1, D2: LED_ALT; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
P1, P2: Conn_01x24_Male; PinHeader_2x12_P2.54mm_Vertical
P3: Conn_01x18_Male; PinHeader_2x09_P2.54mm_Vertical
R1, R2: 330Ω; R_SMD_0805_2012Metric_Pad1.15x1.40mm_HandSolder
RN1, RN2, RN3, RN4: 30Ω; R_Array_Convex_4x0402
U1, U2, U3, U4: 74HC574; SOIC-20W
U5: SN74ACT1073; SOIC-20W

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, P1.1, P1.2, P2.9, P2.10, P2.11, P2.12, R1.2, R2.1, U1.20, U2.20, U3.20, U4.20, U5.15, U5.16
/BUSCP: P1.9, U3.11, U4.11
/CP0: P1.10, U1.11
/CP1: P1.21, U2.11
/D0: P2.1, P3.1, U1.19, U3.2, U5.11
/D1: P2.2, P3.2, U1.18, U3.3, U5.10
/D2: P2.3, P3.3, U1.17, U3.4, U5.12
/D3: P2.4, P3.4, U1.16, U3.5, U5.9
/D4: P2.5, P3.5, U1.15, U3.6, U5.13
/D5: P2.6, P3.6, U1.14, U3.7, U5.8
/D6: P2.7, P3.7, U1.13, U3.8, U5.14
/D7: P2.8, P3.8, U1.12, U3.9, U5.7
/D8: P2.13, P3.11, U2.19, U4.2, U5.4
/D9: P2.14, P3.12, U2.18, U4.3, U5.19
/D10: P2.15, P3.13, U2.17, U4.4, U5.20
/D11: P2.16, P3.14, U2.16, U4.5, U5.17
/D12: P2.17, P3.15, U2.15, U4.6, U5.1
/D13: P2.18, P3.16, U2.14, U4.7, U5.18
/D14: P2.19, P3.17, U2.13, U4.8, U5.2
/D15: P2.20, P3.18, U2.12, U4.9, U5.3
/FPD0: P1.5, RN1.8, RN3.8, U1.2, U2.2
/FPD1: P1.6, RN1.7, RN3.7, U1.3, U2.3
/FPD2: P1.7, RN1.6, RN3.6, U1.4, U2.4
/FPD3: P1.8, RN1.5, RN3.5, U1.5, U2.5
/FPD4: P1.17, RN2.8, RN4.8, U1.6, U2.6
/FPD5: P1.20, RN2.7, RN4.7, U1.7, U2.7
/FPD6: P1.19, RN2.6, RN4.6, U1.8, U2.8
/FPD7: P1.22, RN2.5, RN4.5, U1.9, U2.9
/~OE0: P1.3, U1.1
/~OE1: D1.1, P1.15, U2.1
/~R0: P1.4, U3.1
/~R1: D2.1, P1.16, U4.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, P1.11, P1.12, P1.13, P1.14, P1.23, P1.24, P2.21, P2.22, P2.23, P2.24, P3.9, P3.10, U1.10, U2.10, U3.10, U4.10, U5.5, U5.6
unnamed: D1.2, R1.1
unnamed: D2.2, R2.2
unnamed: RN1.1, U3.19
unnamed: RN1.2, U3.18
unnamed: RN1.3, U3.17
unnamed: RN1.4, U3.16
unnamed: RN2.1, U3.15
unnamed: RN2.2, U3.14
unnamed: RN2.3, U3.13
unnamed: RN2.4, U3.12
unnamed: RN3.1, U4.19
unnamed: RN3.2, U4.18
unnamed: RN3.3, U4.17
unnamed: RN3.4, U4.16
unnamed: RN4.1, U4.15
unnamed: RN4.2, U4.14
unnamed: RN4.3, U4.13
unnamed: RN4.4, U4.12
