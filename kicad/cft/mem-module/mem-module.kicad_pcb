# Repository alexiosc/cft (continued)

## KiCad design kicad/cft/mem/mem.kicad_pcb

Board: 2 copper layers, 233.4 x 280.0 mm, 100 parts (0 on the bottom side), 71 nets.

Parts:
C1, C2, C3, C4, C5, C301, C302, C401, C402, C501, C502, C601, C602, C701, C702, C801, C802, C901, C902, C1001, C1002, C1101, C1102, C1201, C1202, C1301, C1302, C1401, C1402, C1501, C1502, C1601, C1602, C1701, C1702, C1801, C1802, C1901, C1902, C2001, C2002: 100nF; SMD_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C101, C103, C104, C106, C109, C110, C111, C112, C113: 47µF; CP_Radial_D6.3mm_P2.50mm
JP1, JP2, JP3, JP6: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP4, JP5: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP7: Jumper_3_Bridged12; PinHeader_1x03_P2.54mm_Horizontal
P1: CFT-2021-Processor-Bus; DIN41612_B_3x32_Horizontal
P2: CFT-2021-Peripheral-Bus; DIN41612_B_3x32_Horizontal
U1, U2, U3: ATF16V8B; DIP-20_W7.62mm_Socket
U4, U5: 29W040; PLCC32
U301, U302, U401, U402, U501, U502, U601, U602, U701, U702, U801, U802, U901, U902, U1001, U1002, U1101, U1102: AS6C4008-55PCN; DIP-32_W15.24mm_Socketed_IC
U1201, U1202, U1301, U1302, U1401, U1402, U1501, U1502, U1601, U1602, U1701, U1702, U1801, U1802, U1901, U1902, U2001, U2002: AS6C4008-55PCN; DIP-32_W15.24mm_Socket

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C101.1, C103.1, C104.1, C106.1, C109.1, C110.1, C111.1, C112.1, C113.1, C301.1, C302.1, C401.1, C402.1, C501.1, C502.1, C601.1, C602.1, C701.1, C702.1, C801.1, C802.1, C901.1, C902.1, C1001.1, C1002.1, C1101.1, C1102.1, C1201.1, C1202.1, C1301.1, C1302.1, C1401.1, C1402.1, C1501.1, C1502.1, C1601.1, C1602.1, C1701.1, C1702.1, C1801.1, C1802.1, C1901.1, C1902.1, C2001.1, C2002.1, JP7.1, P1.A1, P1.B1, P1.C1, P2.A1, P2.A2, P2.B1, P2.B2, P2.C1, P2.C2, U1.20, U2.20, U3.20, U4.32, U5.32, U301.32, U302.32, U401.32, U402.32, U501.32, U502.32, U601.32, U602.32, U701.32, U702.32, U801.32, U802.32, U901.32, U902.32, U1001.32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
/AB0: P2.C4, U4.12, U5.12, U301.12, U302.12, U401.12, U402.12, U501.12, U502.12, U601.12, U602.12, U701.12, U702.12, U801.12, U802.12, U901.12, U902.12, U1001.12, U1002.12, U1101.12, U1102.12, U1201.12, U1202.12, U1301.12, U1302.12, U1401.12, U1402.12, U1501.12, U1502.12, U1601.12, U1602.12, U1701.12, U1702.12, U1801.12, U1802.12, U1901.12, U1902.12, U2001.12, U2002.12
/AB1: P2.C5, U4.11, U5.11, U301.11, U302.11, U401.11, U402.11, U501.11, U502.11, U601.11, U602.11, U701.11, U702.11, U801.11, U802.11, U901.11, U902.11, U1001.11, U1002.11, U1101.11, U1102.11, U1201.11, U1202.11, U1301.11, U1302.11, U1401.11, U1402.11, U1501.11, U1502.11, U1601.11, U1602.11, U1701.11, U1702.11, U1801.11, U1802.11, U1901.11, U1902.11, U2001.11, U2002.11
/AB2: P2.C6, U4.10, U5.10, U301.10, U302.10, U401.10, U402.10, U501.10, U502.10, U601.10, U602.10, U701.10, U702.10, U801.10, U802.10, U901.10, U902.10, U1001.10, U1002.10, U1101.10, U1102.10, U1201.10, U1202.10, U1301.10, U1302.10, U1401.10, U1402.10, U1501.10, U1502.10, U1601.10, U1602.10, U1701.10, U1702.10, U1801.10, U1802.10, U1901.10, U1902.10, U2001.10, U2002.10
/AB3: P2.C7, U4.9, U5.9, U301.9, U302.9, U401.9, U402.9, U501.9, U502.9, U601.9, U602.9, U701.9, U702.9, U801.9, U802.9, U901.9, U902.9, U1001.9, U1002.9, U1101.9, U1102.9, U1201.9, U1202.9, U1301.9, U1302.9, U1401.9, U1402.9, U1501.9, U1502.9, U1601.9, U1602.9, U1701.9, U1702.9, U1801.9, U1802.9, U1901.9, U1902.9, U2001.9, U2002.9
/AB4: P2.C8, U4.8, U5.8, U301.8, U302.8, U401.8, U402.8, U501.8, U502.8, U601.8, U602.8, U701.8, U702.8, U801.8, U802.8, U901.8, U902.8, U1001.8, U1002.8, U1101.8, U1102.8, U1201.8, U1202.8, U1301.8, U1302.8, U1401.8, U1402.8, U1501.8, U1502.8, U1601.8, U1602.8, U1701.8, U1702.8, U1801.8, U1802.8, U1901.8, U1902.8, U2001.8, U2002.8
/AB5: P2.C9, U4.7, U5.7, U301.7, U302.7, U401.7, U402.7, U501.7, U502.7, U601.7, U602.7, U701.7, U702.7, U801.7, U802.7, U901.7, U902.7, U1001.7, U1002.7, U1101.7, U1102.7, U1201.7, U1202.7, U1301.7, U1302.7, U1401.7, U1402.7, U1501.7, U1502.7, U1601.7, U1602.7, U1701.7, U1702.7, U1801.7, U1802.7, U1901.7, U1902.7, U2001.7, U2002.7
/AB6: P2.C10, U4.6, U5.6, U301.6, U302.6, U401.6, U402.6, U501.6, U502.6, U601.6, U602.6, U701.6, U702.6, U801.6, U802.6, U901.6, U902.6, U1001.6, U1002.6, U1101.6, U1102.6, U1201.6, U1202.6, U1301.6, U1302.6, U1401.6, U1402.6, U1501.6, U1502.6, U1601.6, U1602.6, U1701.6, U1702.6, U1801.6, U1802.6, U1901.6, U1902.6, U2001.6, U2002.6
/AB7: P2.C11, U4.5, U5.5, U301.5, U302.5, U401.5, U402.5, U501.5, U502.5, U601.5, U602.5, U701.5, U702.5, U801.5, U802.5, U901.5, U902.5, U1001.5, U1002.5, U1101.5, U1102.5, U1201.5, U1202.5, U1301.5, U1302.5, U1401.5, U1402.5, U1501.5, U1502.5, U1601.5, U1602.5, U1701.5, U1702.5, U1801.5, U1802.5, U1901.5, U1902.5, U2001.5, U2002.5
/AB8: P2.C15, U4.27, U5.27, U301.27, U302.27, U401.27, U402.27, U501.27, U502.27, U601.27, U602.27, U701.27, U702.27, U801.27, U802.27, U901.27, U902.27, U1001.27, U1002.27, U1101.27, U1102.27, U1201.27, U1202.27, U1301.27, U1302.27, U1401.27, U1402.27, U1501.27, U1502.27, U1601.27, U1602.27, U1701.27, U1702.27, U1801.27, U1802.27, U1901.27, U1902.27, U2001.27, U2002.27
/AB9: P2.C16, U4.26, U5.26, U301.26, U302.26, U401.26, U402.26, U501.26, U502.26, U601.26, U602.26, U701.26, U702.26, U801.26, U802.26, U901.26, U902.26, U1001.26, U1002.26, U1101.26, U1102.26, U1201.26, U1202.26, U1301.26, U1302.26, U1401.26, U1402.26, U1501.26, U1502.26, U1601.26, U1602.26, U1701.26, U1702.26, U1801.26, U1802.26, U1901.26, U1902.26, U2001.26, U2002.26
/AB10: P2.C17, U4.23, U5.23, U301.23, U302.23, U401.23, U402.23, U501.23, U502.23, U601.23, U602.23, U701.23, U702.23, U801.23, U802.23, U901.23, U902.23, U1001.23, U1002.23, U1101.23, U1102.23, U1201.23, U1202.23, U1301.23, U1302.23, U1401.23, U1402.23, U1501.23, U1502.23, U1601.23, U1602.23, U1701.23, U1702.23, U1801.23, U1802.23, U1901.23, U1902.23, U2001.23, U2002.23
/AB11: P2.C18, U4.25, U5.25, U301.25, U302.25, U401.25, U402.25, U501.25, U502.25, U601.25, U602.25, U701.25, U702.25, U801.25, U802.25, U901.25, U902.25, U1001.25, U1002.25, U1101.25, U1102.25, U1201.25, U1202.25, U1301.25, U1302.25, U1401.25, U1402.25, U1501.25, U1502.25, U1601.25, U1602.25, U1701.25, U1702.25, U1801.25, U1802.25, U1901.25, U1902.25, U2001.25, U2002.25
/AB12: P2.C19, U4.4, U5.4, U301.4, U302.4, U401.4, U402.4, U501.4, U502.4, U601.4, U602.4, U701.4, U702.4, U801.4, U802.4, U901.4, U902.4, U1001.4, U1002.4, U1101.4, U1102.4, U1201.4, U1202.4, U1301.4, U1302.4, U1401.4, U1402.4, U1501.4, U1502.4, U1601.4, U1602.4, U1701.4, U1702.4, U1801.4, U1802.4, U1901.4, U1902.4, U2001.4, U2002.4
/AB13: P2.C20, U4.28, U5.28, U301.28, U302.28, U401.28, U402.28, U501.28, U502.28, U601.28, U602.28, U701.28, U702.28, U801.28, U802.28, U901.28, U902.28, U1001.28, U1002.28, U1101.28, U1102.28, U1201.28, U1202.28, U1301.28, U1302.28, U1401.28, U1402.28, U1501.28, U1502.28, U1601.28, U1602.28, U1701.28, U1702.28, U1801.28, U1802.28, U1901.28, U1902.28, U2001.28, U2002.28
/AB14: P2.C21, U4.29, U5.29, U301.3, U302.3, U401.3, U402.3, U501.3, U502.3, U601.3, U602.3, U701.3, U702.3, U801.3, U802.3, U901.3, U902.3, U1001.3, U1002.3, U1101.3, U1102.3, U1201.3, U1202.3, U1301.3, U1302.3, U1401.3, U1402.3, U1501.3, U1502.3, U1601.3, U1602.3, U1701.3, U1702.3, U1801.3, U1802.3, U1901.3, U1902.3, U2001.3, U2002.3
/AB15: P2.C22, U4.3, U5.3, U301.31, U302.31, U401.31, U402.31, U501.31, U502.31, U601.31, U602.31, U701.31, U702.31, U801.31, U802.31, U901.31, U902.31, U1001.31, U1002.31, U1101.31, U1102.31, U1201.31, U1202.31, U1301.31, U1302.31, U1401.31, U1402.31, U1501.31, U1502.31, U1601.31, U1602.31, U1701.31, U1702.31, U1801.31, U1802.31, U1901.31, U1902.31, U2001.31, U2002.31
/AB16: P2.B23, U4.2, U5.2, U301.2, U302.2, U401.2, U402.2, U501.2, U502.2, U601.2, U602.2, U701.2, U702.2, U801.2, U802.2, U901.2, U902.2, U1001.2, U1002.2, U1101.2, U1102.2, U1201.2, U1202.2, U1301.2, U1302.2, U1401.2, U1402.2, U1501.2, U1502.2, U1601.2, U1602.2, U1701.2, U1702.2, U1801.2, U1802.2, U1901.2, U1902.2, U2001.2, U2002.2
/AB17: P2.B24, U4.30, U5.30, U301.30, U302.30, U401.30, U402.30, U501.30, U502.30, U601.30, U602.30, U701.30, U702.30, U801.30, U802.30, U901.30, U902.30, U1001.30, U1002.30, U1101.30, U1102.30, U1201.30, U1202.30, U1301.30, U1302.30, U1401.30, U1402.30, U1501.30, U1502.30, U1601.30, U1602.30, U1701.30, U1702.30, U1801.30, U1802.30, U1901.30, U1902.30, U2001.30, U2002.30
/AB18: P2.B25, U4.1, U5.1, U301.1, U302.1, U401.1, U402.1, U501.1, U502.1, U601.1, U602.1, U701.1, U702.1, U801.1, U802.1, U901.1, U902.1, U1001.1, U1002.1, U1101.1, U1102.1, U1201.1, U1202.1, U1301.1, U1302.1, U1401.1, U1402.1, U1501.1, U1502.1, U1601.1, U1602.1, U1701.1, U1702.1, U1801.1, U1802.1, U1901.1, U1902.1, U2001.1, U2002.1
/AB19: P2.B26, U1.1, U2.1, U3.1
/AB20: P2.B27, U1.2, U2.2, U3.2
/AB21: P2.B28, U1.3, U2.3, U3.3
/AB22: P2.B29, U1.4, U2.4, U3.4
/AB23: P2.B30, U1.5, U2.5, U3.5
/DB0: P2.A15, U5.13, U301.13, U401.13, U501.13, U601.13, U701.13, U801.13, U901.13, U1001.13, U1101.13, U1201.13, U1301.13, U1401.13, U1501.13, U1601.13, U1701.13, U1801.13, U1901.13, U2001.13
/DB1: P2.A16, U5.14, U301.14, U401.14, U501.14, U601.14, U701.14, U801.14, U901.14, U1001.14, U1101.14, U1201.14, U1301.14, U1401.14, U1501.14, U1601.14, U1701.14, U1801.14, U1901.14, U2001.14
/DB2: P2.A17, U5.15, U301.15, U401.15, U501.15, U601.15, U701.15, U801.15, U901.15, U1001.15, U1101.15, U1201.15, U1301.15, U1401.15, U1501.15, U1601.15, U1701.15, U1801.15, U1901.15, U2001.15
/DB3: P2.A18, U5.17, U301.17, U401.17, U501.17, U601.17, U701.17, U801.17, U901.17, U1001.17, U1101.17, U1201.17, U1301.17, U1401.17, U1501.17, U1601.17, U1701.17, U1801.17, U1901.17, U2001.17
/DB4: P2.A19, U5.18, U301.18, U401.18, U501.18, U601.18, U701.18, U801.18, U901.18, U1001.18, U1101.18, U1201.18, U1301.18, U1401.18, U1501.18, U1601.18, U1701.18, U1801.18, U1901.18, U2001.18
/DB5: P2.A20, U5.19, U301.19, U401.19, U501.19, U601.19, U701.19, U801.19, U901.19, U1001.19, U1101.19, U1201.19, U1301.19, U1401.19, U1501.19, U1601.19, U1701.19, U1801.19, U1901.19, U2001.19
/DB6: P2.A21, U5.20, U301.20, U401.20, U501.20, U601.20, U701.20, U801.20, U901.20, U1001.20, U1101.20, U1201.20, U1301.20, U1401.20, U1501.20, U1601.20, U1701.20, U1801.20, U1901.20, U2001.20
/DB7: P2.A22, U5.21, U301.21, U401.21, U501.21, U601.21, U701.21, U801.21, U901.21, U1001.21, U1101.21, U1201.21, U1301.21, U1401.21, U1501.21, U1601.21, U1701.21, U1801.21, U1901.21, U2001.21
/DB8: P2.A23, U4.13, U302.13, U402.13, U502.13, U602.13, U702.13, U802.13, U902.13, U1002.13, U1102.13, U1202.13, U1302.13, U1402.13, U1502.13, U1602.13, U1702.13, U1802.13, U1902.13, U2002.13
/DB9: P2.A24, U4.14, U302.14, U402.14, U502.14, U602.14, U702.14, U802.14, U902.14, U1002.14, U1102.14, U1202.14, U1302.14, U1402.14, U1502.14, U1602.14, U1702.14, U1802.14, U1902.14, U2002.14
/DB10: P2.A25, U4.15, U302.15, U402.15, U502.15, U602.15, U702.15, U802.15, U902.15, U1002.15, U1102.15, U1202.15, U1302.15, U1402.15, U1502.15, U1602.15, U1702.15, U1802.15, U1902.15, U2002.15
/DB11: P2.A26, U4.17, U302.17, U402.17, U502.17, U602.17, U702.17, U802.17, U902.17, U1002.17, U1102.17, U1202.17, U1302.17, U1402.17, U1502.17, U1602.17, U1702.17, U1802.17, U1902.17, U2002.17
/DB12: P2.A27, U4.18, U302.18, U402.18, U502.18, U602.18, U702.18, U802.18, U902.18, U1002.18, U1102.18, U1202.18, U1302.18, U1402.18, U1502.18, U1602.18, U1702.18, U1802.18, U1902.18, U2002.18
/DB13: P2.A28, U4.19, U302.19, U402.19, U502.19, U602.19, U702.19, U802.19, U902.19, U1002.19, U1102.19, U1202.19, U1302.19, U1402.19, U1502.19, U1602.19, U1702.19, U1802.19, U1902.19, U2002.19
/DB14: P2.A29, U4.20, U302.20, U402.20, U502.20, U602.20, U702.20, U802.20, U902.20, U1002.20, U1102.20, U1202.20, U1302.20, U1402.20, U1502.20, U1602.20, U1702.20, U1802.20, U1902.20, U2002.20
/DB15: P2.A30, U4.21, U302.21, U402.21, U502.21, U602.21, U702.21, U802.21, U902.21, U1002.21, U1102.21, U1202.21, U1302.21, U1402.21, U1502.21, U1602.21, U1702.21, U1802.21, U1902.21, U2002.21
/~CS0: U1.19, U301.22, U302.22
/~CS1: U1.18, U401.22, U402.22
/~CS2: U1.17, U501.22, U502.22
/~CS3: U1.16, U601.22, U602.22
/~CS4: U1.15, U701.22, U702.22
/~CS5: U1.14, U801.22, U802.22
/~CS6: U1.13, U901.22, U902.22
/~CS7: U1.12, U1001.22, U1002.22
/~CS8: U3.19, U1101.22, U1102.22
/~CS9: U3.18, U1201.22, U1202.22
/~CS10: U3.17, U1301.22, U1302.22
/~CS11: U3.16, U1401.22, U1402.22
/~CS12: U3.15, U1501.22, U1502.22
/~CS13: U3.14, U1601.22, U1602.22
/~CS14: U3.13, U1701.22, U1702.22
/~CS15: U3.12, U1801.22, U1802.22
/~CS16: U2.19, U4.22, U5.22
/~CS20: U2.15, U1901.22, U1902.22
/~CS21: U2.14, U2001.22, U2002.22
/~MEM: P2.B10, U1.6, U2.6, U3.6
/~R: P2.C12, U4.24, U5.24, U301.24, U302.24, U401.24, U402.24, U501.24, U502.24, U601.24, U602.24, U701.24, U702.24, U801.24, U802.24, U901.24, U902.24, U1001.24, U1002.24, U1101.24, U1102.24, U1201.24, U1202.24, U1301.24, U1302.24, U1401.24, U1402.24, U1501.24, U1502.24, U1601.24, U1602.24, U1701.24, U1702.24, U1801.24, U1802.24, U1901.24, U1902.24, U2001.24, U2002.24
/~ROMW: JP7.2, U4.31, U5.31
/~W: JP7.3, P2.C13, U301.29, U302.29, U401.29, U402.29, U501.29, U502.29, U601.29, U602.29, U701.29, U702.29, U801.29, U802.29, U901.29, U902.29, U1001.29, U1002.29, U1101.29, U1102.29, U1201.29, U1202.29, U1301.29, U1302.29, U1401.29, U1402.29, U1501.29, U1502.29, U1601.29, U1602.29, U1701.29, U1702.29, U1801.29, U1802.29, U1901.29, U1902.29, U2001.29, U2002.29
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C101.2, C103.2, C104.2, C106.2, C109.2, C110.2, C111.2, C112.2, C113.2, C301.2, C302.2, C401.2, C402.2, C501.2, C502.2, C601.2, C602.2, C701.2, C702.2, C801.2, C802.2, C901.2, C902.2, C1001.2, C1002.2, C1101.2, C1102.2, C1201.2, C1202.2, C1301.2, C1302.2, C1401.2, C1402.2, C1501.2, C1502.2, C1601.2, C1602.2, C1701.2, C1702.2, C1801.2, C1802.2, C1901.2, C1902.2, C2001.2, C2002.2, JP1.1, JP2.1, JP3.1, JP4.1, JP5.1, JP6.1, P1.A31, P1.A32, P1.B4, P1.B5, P1.B31, P1.B32, P1.C31, P1.C32, P2.A31, P2.A32, P2.B31, P2.B32, P2.C31, P2.C32, U1.10, U2.10, U3.10, U4.16, U5.16, U301.16, U302.16, U401.16, U402.16, U501.16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
unnamed: JP1.2, U1.7
unnamed: JP2.2, U1.8
unnamed: JP3.2, U3.7
unnamed: JP4.2, U3.8
unnamed: JP5.2, U2.7
unnamed: JP6.2, U2.8

## Commit log (part)

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2021-03-29 Remove T34 from MBU read enables
2021-04-02 Draw 6U×160mm board
2021-04-02 Route board0
2021-04-03 Route board 0
2021-04-04 Update tests for new MBU
2021-04-04 Add R to DFP base
2021-04-04 Fix mnemonic in comment
2021-04-04 Refactor tests for new MBU
2021-04-04 Add missing name to bitmap instructions
2021-04-04 Add builtins from latest microcode revision
2021-04-30 Cleaning up board
2021-05-01 Fine tune board0
2021-05-02 ERC/DRC board 0, route, fine-tune
2021-05-03 Work on Board 0 schematics
2021-05-03 Fine-tune Board 0
2021-05-03 Work around MBU IBus not driving bits 15-8 (for testing)
2021-05-03 Fine-tune board0
2021-05-04 Add NCT and ECT context-management instructions
2021-05-04 Add NCT and ECT instructions
2021-05-04 Bring decoding filters in sync with microcode
2021-05-04 Update tests for current MBU
2021-05-04 Update flag unit for latest design
2021-05-04 Clean up silkscreen
2021-05-04 Re-add holes and logos
2021-05-06 Move to explicit constant store names for clarity
2021-05-06 Fix tests for new MBU
2021-05-06 Improve text fields
2021-05-06 Annotate board
2021-05-06 Documenting PCB
2021-05-08 Reimplement NCT so it (probably) works
2021-05-08 Change erroneous use of NCT to SCT
2021-05-09 Change NCT broken instruction to NMB
2021-05-09 Add MBU address decoder
2021-05-09 Change NCT instruction to NMB
2021-05-09 Fix minor issues and rebuild
2021-05-09 Drive high IBUS when CTX is read too
2021-05-09 Fix serious issue with definition of '157 MUX
2021-05-09 Add missing pull-down resistors
2021-05-09 Rename 74x257 pins
2021-05-09 Add missing pull-downs
2021-05-09 Add testbench for '257
2021-05-09 Swap ISR and TRAP vectors
2021-05-09 Fix test scripts
2021-05-10 Fix microcode bug in WAIT
2021-05-10 Remove high IBUS drive during CTX reads
2021-05-10 Move AB8-15 on peripheral connector
2021-05-10 Fix interrupt tests
2021-05-11 Add test for validity of UOP, IFL and IFV opcodes
2021-05-11 Fix IFL and IFV opcodes
2021-05-12 Improve DIP footprints
2021-05-12 Clean up schematics
2021-05-12 Clean up board
2021-05-12 Review board before printing
2021-05-12 Rearrange sheet numbers, prepare for layout
2021-05-13 Renumber schematics, start of board layout
2021-05-13 Add ALU GALs
2021-05-13 Layout board 1
2021-05-13 Work on board 1
2021-05-13 Route board 1
2021-05-17 Schematic and routing work
2021-05-17 PLD rework, tests
2021-05-17 Readd IRC bus interface sheet
2021-05-18 Work on Board1 schematics and PCB
2021-05-18 Print out chip pinout after successful PLD build
2021-05-18 Make CLRV and SETV assert on READ-ALY-U and add ALU-OE output
2021-05-20 Drop CXO & 16 MHz driver Vcc, add series resistors
2021-05-20 Use stashed version of PCB
2021-05-20 Work on board1
2021-05-28 Move pins around for ease of routing
2021-05-28 Add shift/rotate unit control GAL
2021-05-28 Add open 2-pad solder jumper
2021-05-29 Add two additional toggle input pins for toggles when AC wraps around
2021-05-29 Move to GAL for IRC decoding
2021-05-29 Add IRC decode GAL
2021-05-29 Fix IRC schematics and route Board 1
2021-05-29 Rename 16V8 to indicate pins 12 & 19 are output only
2021-06-06 Fine-tune board 1
2021-06-13 Update control unit with new MBR
2021-06-14 Finish adding new MBU to emulator.
2021-06-14 Move designators off vias.
2021-06-14 Update 16V8 symbol
2021-06-14 Add ISR/IER LEDs, route board
2021-06-19 Fine-tuning Board 1
2021-06-19 Fix IC alignment
2021-06-21 Move MEM board out of the way
2021-06-22 Start MEM board schematic, clean up old files
2021-06-22 Add MEM decoder PLD
2021-06-22 Add DIP32 package
2021-06-22 Improve SOJ36 land patterns for hand soldering
2021-06-22 Work on MEM schematics and board
2021-06-22 Add DIP32 footprints
2021-06-22 Route MEM board
2021-06-24 Fine-tune MEM board
2021-06-25 Inhihit the SRU on halt
2021-06-27 Move backplane project out of the way
2021-06-27 Copy board0 to backplane
2021-06-28 Add DIN backplane
2021-06-28 Work on DIN backplane
2021-06-28 Add single slot sheet
2021-06-28 Add 3D model
2021-06-28 Work on boards
2021-07-01 Work on backplane
2021-07-05 Move IRQS signal.
2021-07-05 Use project-wide library
2021-07-05 Fix AS6C4008-55PCN symbol
2021-07-05 Work on backplane bus hold
2021-07-11 Work on 2021 DFP
2021-07-11 Move IRQS signal
2021-07-11 Renumber ICs
2021-07-11 Add 16V8
2021-07-11 Modify DFP to accept Arduino Mega 2560, place and route
2021-07-11 Add Arduino Mega 2560
2021-07-11 Make silkscreen outline bolder
2021-07-11 Move signals around
2021-07-11 Move pins on peripheral connector pinout to allow for 12V supply
2021-07-11 Fine-tune pod board
2021-07-11 Shuffle peripheral pinout to allow for 12V
2021-07-13 Remove POWEROK from unbussed pinout
2021-07-14 Work on the DFP board
2021-07-14 Mark no-connect pins
2021-07-16 Add 8-resistor resistor pack symbol
2021-07-16 Work on DFP
2021-07-16 Simplify and lay out DFP
2021-07-17 Add new footprints
2021-07-17 Add DFP GALs
2021-07-17 Fix 3D model positions
2021-07-17 Add DFP peripheral decoding
2021-07-18 Add DIP resistor pack
2021-07-18 Add new 8-bit pod sub-schematic
2021-07-19 Added FPOExx decoders
2021-07-19 Add decoder GALs and route signals.
2021-07-20 Route DFP board
2021-07-21 Route DFP
2021-07-21 Remove FPRESET signal
2021-08-02 Rework pinout
2021-08-03 Rework pinout of DFP run-stop GAL
2021-08-05 Rearrange front panel modules, add MFD2 and AB/DB to panel v.11
2021-08-05 Assign signals to GALs
2021-08-05 Wire DFP for front panel version 11
2021-08-06 Adjusted pinout of FPOE D gal
2021-08-08 Semi-automate FP OE GAL equations and regenerate
2021-08-08 Fix syntax error
2021-08-08 Make DFP optional
2021-08-08 Add fake bus-hold to LMB instruction
2021-08-08 Update tests for emulator and verilog
2021-08-10 Shuffle pinout to ease routing
2021-08-10 Fix one semantics comment
2021-08-12 Routing DFP board
2021-08-12 Adjust whitepace
2021-08-12 Routing
2021-08-13 Work on DFP silkscreen
2021-08-14 Fine-tune DFP board
2021-08-14 Update to current HW implementation
2021-08-14 Fix RTC detect pattern
2021-08-14 Refill copper pours
2021-08-14 Fine-tuning DFP board
2021-08-15 Fine-tuning DFP board, add signal conditioning, fix minor bugs
2021-08-15 Fix device name case
2021-08-15 Simplify DFP enable equations
2021-08-15 Fix DRC/ERC bugs
2021-08-15 Restructure schematics, fix major I/O pod bug
2021-08-15 Fix DFP pod issues
2021-08-16 Fine-tune DFP board and schematics
2021-08-16 Clean up DFP project files
2021-08-17 Start merge of SRI and TIC boards
2021-08-17 Clean up DFP
2021-08-17 Add RTC model
2021-08-21 Restore file deleted by mistake
2021-08-21 Renamed
2021-08-21 Renamed edge connector to bus connector
2021-08-21 Fine tuning DFP board
2021-08-21 TIC board
2021-08-22 Added SWAB instruction
2021-08-22 Add SWAB instruction
2021-08-26 Split backplanesl; route processor backplane
2021-08-26 Clarify comment
2021-08-26 Work on DFP and TTY boards
2021-08-26 Remove silkscreen boxes from 0805 footprints
2021-08-26 Work on Processor Backplane
2021-08-27 Complete Processor Backplane, push to fabrication
2021-08-27 Copy processor backplane to peripheral backplane
2021-08-27 Work on Peripheral Backplane
2021-08-28 Add 10 and 12-way CUI pluggable terminal blocks
2021-08-28 Improve DIN 41612 jack silkscreen
2021-08-28 Separate processor and peripheral slot sheets
2021-08-28 Improve silkscreen
2021-08-29 Update footprints, check board artwork, fine tune
2021-08-29 Fine-tune PB0
2021-08-29 Add ST16C554 quad UART
2021-08-29 Move IDE emulation back
2021-08-29 Start porting IDE driver
2021-08-30 Fine-tune PB0 and PB1 boards
2021-09-04 Continue IDE emulator porting work
2021-09-10 Switch to CLK1
2021-09-12 Clean-up IDE driver
2021-09-12 Work on new TIC board
2021-09-14 Move capacitors to make space for subrack rail
2021-09-15 Fine tune board
2021-09-15 Fix bugs, prepare for manufacture
2021-09-18 Add v11 front panel (1 inch taller)
2021-09-19 Clean up gerber outputs
2021-09-19 Prepare processor and peripheral backplane r2134
2021-09-19 Work on TIC schematics
2021-09-19 Rearrange pins on STC16C554, add FL232FL
2021-09-19 Produce revision 2134 for peripheral backplane
2021-09-19 Prepare PB0 r2119 gerbers
2021-09-19 Minor changes to the DFP board pre-fabrication
2021-09-22 Port UART emulation
2021-09-23 Move pre-2019 ROM out of the way for porting
2021-09-23 Move here for historical interest
2021-09-23 Add the very basics for a blank ROM
2021-09-23 Added basic ROM compilation
2021-09-23 Add PLCC68 socket
2021-09-23 Fix eDIP socket 3D
2021-09-23 Fix pinout of STC16C554 and USB6B1
2021-09-23 Work on TIC board
2021-09-23 Minor changes
2021-09-23 Add trivial hello world ROM.
2021-09-23 Add proper TTY support to early DEB
2021-09-24 Fix CLI bug in TRAP instruction
2021-09-24 Add DEB character-level output & colourise TTY output.
2021-09-25 Make autoindex register names more human-friendly
2021-09-25 Fix state output bug; add TRACE output level
2021-09-26 Fix character buffering issue
2021-09-26 Improve readability of instruction tracing
2021-09-26 Add putud subroutine
2021-09-26 Fix bug with negative values, add bound checking
2021-09-26 Add putud routine, start porting generic macros
2021-09-28 Add memcpy and lmemcpy routines
2021-09-29 Move library files to lib/
2021-09-29 Move hardware device files to dev/
2021-10-09 C1503 silkscreen overlaps pads
2021-10-10 Change location of dfp2.asm
2021-10-10 Add script to regenerate BOM
2021-10-10 Will try 74HC74, can't source AC family in DIP
2021-10-11 Fix file dependency for new asm/ tree
2021-10-11 Add putd routine
2021-10-11 Add puth subroutine
2021-10-11 Test out puth
2021-10-11 Mark RN1702 as optional
2021-10-11 Add character literals to cftasm
2021-10-11 Start cleaning up macros
2021-10-23 Remove OE pin from upc-gate
2021-10-24 Rearrange pins for easire routing
2021-10-24 Move DFP I/O decoding to PLDs
2021-10-24 Move pod decoding to PLDs and reroute. Various other fixes
2021-10-24 Add memcpm.asm
2021-10-25 Prepare for Gerber plots
2021-10-26 Plot DFP PCB (rev 2133a) and create order
2021-10-27 Fix INH decoding bug
2021-10-27 Clean up signal names and equations
2021-10-27 Change IDEN to IDXEN
2021-10-27 Add script to generate TL866 test vectors for CFT GALs (temporary location)
2021-10-27 Change permissions
2021-10-28 Improve GAL testing and fix various bugs
2021-10-29 Symlinked to working version of galasm
2021-10-29 Adjust code for Mega 2560, mark unported code
2021-10-29 Ignore minicom text capture files (.cap)
2021-10-29 Registered new submodules
2021-10-29 Port DFP firmware to 2560
2021-10-30 Port driver_dfp to new MCU.
2021-10-30 Fix TTYD location
2021-10-31 Port to Atmega 2560
2021-10-31 Document FPuSTEP erratum
2021-10-31 Fix pin allocation erratum
2021-11-01 Correct table of ALU operations
2021-11-01 Fix signatures/filenames of DP decoder GALs
2021-11-01 Fix spelling error
2021-11-01 Add lost comment for unused RADDR 01110.
2021-11-01 Fix bug where 16-bit values have a ':' prepended
2021-11-01 Add unit-level granularity to detection and diags
2021-11-01 Update pod description
2021-11-02 Update DFP BOM
2021-11-06 Change to UTF-8 DFP terminal
2021-11-06 Fix LED definitions, add banner
2021-11-07 Implement per-unit detection status
2021-11-07 Local changes while testing hardware
2021-11-07 Fix DFP detection logic
2021-11-07 Fix DFP board detection
2021-11-08 Add DFP pod detection
2021-11-08 Work on firmware
2021-11-15 Add bus extender boards
2021-11-17 Route bus extended board
2021-11-18 Add test vectors for dfb-io-X GALs and fix numerous errors
2021-11-18 Add test vectors for dfp-fpoeX GALs
2021-11-19 Add SRAM module adaptor
2021-11-20 Fix IC values that changed due to Kicad bug
2021-11-21 Fix silkscreen error
2021-11-21 Enable bus before reading DFP peripherals
2022-02-21 Add missing newline
2022-02-21 Resolve bus contention issue
2022-02-25 Fix twin PLD bug and PLD *testing* bug causing DFP-IO-A to misbehave
2022-02-26 Update BOM for Board 1
2022-02-28 Switch from XMEM to GPIO for bus operations to respect chip setup times
2022-03-03 Re-enable all pod tests
