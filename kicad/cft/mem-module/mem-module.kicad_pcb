# Repository alexiosc/cft

File README:

# The CFT Home-Brew 16-bit Mini-Computer

The CFT is a home-designed, home-built mini-computer made from
scratch.

I've designed and built the instruction set, data path, processor,
computer, software stack, cross-assembler, emulator, software
toolchain and even some of the tools needed to do all this. You can
call this a ‘fantasy mini’.

This project has been going since approximately 2001, in my Copious
Free Time.

## Audience

There isn't one, so I couldn't tell you what it's like. This project
has been online for since 2005 and it's been noticed by four or five
people. Not quite enough for statistics.

**This is a personal project, and the repository is made public as a
curiosity. Expect everything to be wrong, broken, or dangerous.**

## Why?

Because it's fun.

To see how it's done.

To recall Those Heady Times.

To prove to myself I can do this.

## What?

The CFT is a long-term project built in my Copious Free Time. (a term used, as
always, sarcastically, hence the name) It's a homebrew, self-designed,
self-built Sixties-style 16-bit mini computer built out of 74-family integrated
circuits. Check out the
[ChangeLog](https://github.com/alexiosc/cft/blob/master/Changelog) for the
current status.

There may possibly be more stuff to look at, at https://www.bedroomlan.org/cft.

The project consists of:

* The CFT processor.
* Peripherals and cards, some implementing extensions to the CFT instruction set.
* A front panel with blinkenlights.
* A case for the lot.
* Documentation for everything, including the website and this.
* A cross-toolchain for working on the computer from a PC.

### The CFT Processor

* A 4 MHz clock. (250ns processor cycle)
* 16-bit word length. No byte access.
* 24-bit memory address bus.
* 16-bit I/O bus shared with the address bus. (the lower 1,024 addresses are easier to use)
* All instructions are exactly one 16-bit word long.
* Some instructions follow the PDP-8 ‘microcoded’ format with bitfields cotrolling combinations of actions. Bitwise negation, two's complement negation and incrementation are the same instruction with slightly different options.
* A relatively simple instruction set inspired by the PDP-8. This has moved on
  to something slightly more reminiscent of a modern processor.
* Microcoded design.
* Accumulator based architecture.
* Four user-accessible 16-bit registers with increment and decrement. Only the
  Accumulator (AC) is general purpose.
* PDP-8 style magic addresses working like auto-increment or auto-decrement
  index registers, or stack pointers.

### Peripherals

I originally sat down with Eagle CAD and went *crazy* with it. I had 50 sheets
of schematics for boards, all with a three-letter designator:

* MEM: A memory board with 512 KWords of RAM and 512 KWords of ROM.
* TTY: A quadruple serial board including both DCE and DTE
  connections, and a TTL one for an FTDI USB adaptor.
* INT: 8-interrupt controller board.
* IDE: Twin IDE bus interface for up to four drives.
* RTC: A real-time card with some NVRAM and three or six programmable timers.
* ETH: An offloaded Ethernet interface using the WIZ812 chip.
* KBD: A PS/2 Keyboard interface in pure discrete logic.
* PSG: A sound board with one or two AY-3-8910 chips and a SpeakJet® speech synthesiser.
* PFP: A Programmer's Front Panel capable of debugging microcode as well as full machine code.
* DEB: A DEBugging card to help diagnose problems with the hardware
  using a remote controller. (this was basically a simple, slow, specialised logic analyser)
* FDC: A Floppy Drive Controller for up to four drives, including 8-inch 50-pin ones.
* GIO: General Purpose I/O board including some digital I/O, two
  Atari-style digital joystick ports, a unidirectional parallel
  printer port, four user-controllable LEDs on the front panel (the
  PFP already had 16) and (on a whim) a cassette tape interface.
* MBU: processor extension to allow 21-bit memory addressing (up to 2 MWords).
* µCB: processor extension to allow multiple versions of microcode to co-exist. (I had spare space in the Microcode ROMs)
* VDU: a graphics card that does text at 80×25 and 40×25, and graphics
  at combinations of 160, 320, 640 columns and 100, 200, 400 rows with
  64 colours.

The currently planned peripherals are much more modest in scope, but
they also morphed quite a bit. The processor can now do 24-bit
addressing natively, the current microcode uses all of the available
ROM space and a bunch of cards have joined forces. The current state
of affairs looks like this:

* MEM: (tentative design) 512 kWords or 1 MWord of RAM, 512 KWords of
  ROM. Multiple cards can be installed. If density allows, there'll be
  more chip sockets for RAM.
* INT: 8 interrupt controller board.
* DFP: a big card containing both a remote debugging system and front panel drivers.
* TTY: serial port card, possibly colocated with…
* IDE: one or two IDE sockets for two or four IDE drives. (or CF
  cards, but I like the possibility of having some clunky old drive)
* SND: MIDI sound output. Possibly collocated with…
* VDU: a graphics card that does text at 80×30 and 40×30, and graphics
  at combinations of 160, 320, 640 columns and 120, 240, 480 rows
  using 64 colours. The new VDU card fits inside a CPLD and also
  includes a PS/2 interface.
* RTC: Real-time clock, timers.

I've built the MEM and DFP boards to pre-2019 specs and the computer was
working on them.

The 2019 redesign goes for proper PCBs for everything, so things are
taking a little extra time.

### Front Panel

I was really proud of the front panel before the 2019 redesign, it
worked great and showed the computer's entire status. There's support
for up to 160 lights, 31 switches and two keylocks for that PDP-8
feel.

The downside was the wiring: there were no fewer than *five* 50-wire
ribbon cables going to this crazy bastard.

The 2019 redesign keeps the layout, but can no longer display as much
of the computer's status on the front panel. I'm working on it. On the
upside, it now serialises data transmission and only a single 40-pin
cable is needed.

To cut costs, the original front panel was made out of eight modules,
each with up to 20 LEDs. The new front panel is made out of four
modules, each with up to 40 LEDs. Each module daisy-chains to the
next.

Switches are mounted on a separate plate and wired to a break-out
board, or the closest front panel modules on the 2019 version.

### The Case

Two words: wood paneling. Well, and a black acrylic front piece. The
rest will depend on how big the card cage gets, but I'll scratch make
the case out of sheet aluminium and wood.

### Documentation

There's just too much of it. The documentation was initially in LaTeX
and got up to 500 pages before I gave that up and started converting
it to HTML.

The 2019 redesign will need a redo of most of this, sadly, but the
current documents for hardware that's currently around are available
at https://www.bedroomlan.org/hardware/cft/book/.

### Software and Hardware Tools

I had to make my own tools for some of this, and *wanted* to make my
own for some other parts.

Hardware tools include
[Flashprog](https://www.bedroomlan.org/hardware/flashprog/), a
zero-parts flash programmer with a modern serial interface. The
interface formed the basis of the DEB and DFP cards' remote debugging
interface and I'm quite happy with it.

Software tools include:

* The [Microcode
  Assembler](https://www.bedroomlan.org/projects/mcasm/), also
  available on Github as https://github.com/alexiosc/mcasm.
* The CFT Assembler, written purely in Python and roughly based on
  PDP-8 Assemblers, but with some modern extras like namespaces and
  simple macros.
* Too many emulators to speak of!
    ** A basic microcode-level emulator in Python to verify the original
	design. This one is dead and buried, but still in the repository.
	** A Verilog emulator used to verify the hardware.
	** A C emulator that's fast enough to run software on.
	** A [Javascript microcode-level
    emulator](https://www.bedroomlan.org/hardware/cft/microcode-emulator/)
    that runs on the web. It's very slow, but it shows how the front
    panel works.
	** A newer JS-based emulator meant to me much faster. Still
    largely in the works, because I prefer the C-based emulator for
    testing.
* A testing framework that can run test suites on any emulator we can
  use.
* A basic Operating System for the CFT.
* A self-documenting Forth interpreter written in Assembly and Forth.

## KiCad design kicad/cft/mem-module/mem-module.kicad_pcb

Board: 4 copper layers, 20.3 x 43.2 mm, 4 parts (2 on the bottom side), 32 nets.

Parts:
C1, C2: 100nF; SMD_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U1: IS61C5128AL; SOJ-36_10.16x23.49mm_P1.27mm
U2: AS6C4008-55PCN; DIP-32_W15.24mm_Socketed_IC

Connections:
+5V: C1.1, C2.1, U1.9, U1.27, U2.32
/AB0: U1.1, U2.12
/AB1: U1.2, U2.11
/AB2: U1.3, U2.10
/AB3: U1.4, U2.9
/AB4: U1.5, U2.8
/AB5: U1.14, U2.7
/AB6: U1.15, U2.6
/AB7: U1.16, U2.5
/AB8: U1.17, U2.27
/AB9: U1.18, U2.26
/AB10: U1.20, U2.23
/AB11: U1.21, U2.25
/AB12: U1.22, U2.4
/AB13: U1.23, U2.28
/AB14: U1.24, U2.3
/AB15: U1.32, U2.31
/AB16: U1.33, U2.2
/AB17: U1.34, U2.30
/AB18: U1.35, U2.1
/DB8: U1.7, U2.13
/DB9: U1.8, U2.14
/DB10: U1.11, U2.15
/DB11: U1.12, U2.17
/DB12: U1.25, U2.18
/DB13: U1.26, U2.19
/DB14: U1.29, U2.20
/DB15: U1.30, U2.21
/~CE: U1.6, U2.22
/~R: U1.31, U2.24
/~W: U1.13, U2.29
GND: C1.2, C2.2, U1.10, U1.28, U2.16

## KiCad design kicad/cft/cft-dfp/cft-dfp.kicad_pcb

Board: 2 copper layers, 233.4 x 280.0 mm, 197 parts (25 on the bottom side), 415 nets.

Parts:
C3, C4, C5, C11, C28, C29, C34, C38, C40, C41, C43, C201, C202, C301, C302, C303, C304, C305, C306, C307, C308, C309, C401, C402, C501, C502, C601, C602, C701, C702, C801, C802, C901, C902, C1001, C1002, C1101, C1102, C1201, C1202, C1301, C1302, C1401, C1402, C1901, C1902, C1903, C1904: 100nF; C_SMD_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C12: 1µF; C_SMD_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C17, C18, C19, C20, C21, C101, C104, C106, C109, C113: 47µF; CP_Radial_D6.3mm_P2.50mm
C22: 100µF, 16V; CP_Radial_D6.3mm_P2.50mm
D1, D2, D3, D4, D2001: LED_ALT; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D17, D18, D19, D20: PESD5V2S2UT; SOT-23
J1: Conn_01x06; PinHeader_1x06_P2.54mm_Horizontal
J2: Conn_02x15_Odd_Even; IDC-Header_2x15_P2.54mm_Horizontal
J8: Arduino-Mega-2560; Arduino-Mega-2560-Mezzanine-Upside-Down
JP1, JP7, JP9, JP501: SolderJumper_3_Bridged12; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm
JP2: SolderJumper_3_Bridged23; SolderJumper-3_P1.3mm_Bridged23_RoundedPad1.0x1.5mm
JP3: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
P1, P2: CFT-2021-Processor-Bus; DIN41612_B_3x32_Horizontal
R1, R2, R5, R6, R7, R8, R1501, R1502, R1503, R1504, R2001: 1kΩ; R_SMD_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R3, R36, R37, R38, R39, R40, R41, R201, R202: 30Ω; R_SMD_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R4, R10, R12, R13, R203, R204, R205, R206, R402, R1901: 10kΩ; R_SMD_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R14, R901, R902, R903, R904, R905: 1kΩ?; R_SMD_0805_2012Metric_Pad1.15x1.40mm_HandSolder
RN4: 30Ω; R_Array_Convex_4x0603
RN7, RN1702: 10kΩ; R_Array_SIP9
RN15, RN16, RN17: 4.7kΩ; R_Array_SIP9
RN401, RN402: 10kΩ; R_Array_Convex_4x0603
RN501, RN601, RN701, RN801, RN904, RN1001, RN1101, RN1201, RN1301, RN1401, RN1701, RN1703: 1kΩ; Resistor-Pack-DIP-16_W7.62mm
SPARE: C_SMD_0805_2012Metric_Pad1.15x1.40mm_HandSolder
SPARE#2, SPARE#3, SPARE#4: C_SMD_0805_2012Metric_Pad1.15x1.40mm_HandSolder
SPARE#5, SPARE#6, SPARE#7, SPARE#8: DIP-20_W7.62mm_Socket
SW1: momentary_switch; SW_Tactile_SPST_Angled_PTS645Vx39-2LFS
SW2, SW3, SW4: SW_DIP_x08; SW_DIP_SPSTx08_Piano_10.8x21.88mm_W7.62mm_P2.54mm
TP3: TestPoint; TestPoint_THTPad_1.0x1.0mm_Drill0.5mm
U3: 74AC573; DIP-20_W7.62mm_Socket
U4: 74HC590; DIP-16_W7.62mm_Socket
U5: 74HC245; DIP-20_W7.62mm_Socket
U28, U29, U305, U306, U307, U308, U309: 74HC541; DIP-20_W7.62mm_Socket
U34: 74HC138; DIP-16_W7.62mm_Socket
U38: 74HC540; DIP-20_W7.62mm_Socket
U40, U201, U301, U302, U303, U304, U1901, U1902, U1903, U1904: ATF16V8B; DIP-20_W7.62mm_Socket
U41: 74HC112; DIP-16_W7.62mm_Socket
U43: 74LVC1G07; SOT-23-5_HandSoldering
U202: 74HC74; DIP-14_W7.62mm_Socket
U401, U402: 74HC08; DIP-14_W7.62mm_Socket
U501, U502, U601, U602, U701, U702, U801, U802, U901, U902, U1001, U1002, U1101, U1102, U1201, U1202, U1301, U1302, U1401, U1402: 74HC574; DIP-20_W7.62mm_Socket
X1: 7.3728 MHz?; Oscillator_DIP-8-socket

Connections:
+5V: C3.1, C4.1, C5.1, C11.1, C12.1, C17.1, C18.1, C19.1, C20.1, C21.1, C28.1, C29.1, C34.1, C38.1, C40.2, C41.2, C43.1, C101.1, C104.1, C106.1, C109.1, C113.1, C201.1, C202.1, C301.1, C302.1, C303.1, C304.1, C305.1, C306.1, C307.1, C308.1, C309.1, C401.1, C402.1, C501.1, C502.1, C601.1, C602.1, C701.1, C702.1, C801.1, C802.1, C901.1, C902.1, C1001.1, C1002.1, C1101.1, C1102.1, C1201.1, C1202.1, C1301.1, C1302.1, C1401.1, C1402.1, C1901.1, C1902.1, C1903.1, C1904.1, J2.1, J2.2, P1.A1, P1.B1, P1.C1, P2.A1, P2.A2, P2.B1, P2.B2, P2.C1, P2.C2, R10.1, R12.2, R13.2, R203.1, R204.1, R205.1, R206.2, R402.1, RN401.5, RN401.6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
+12V: C22.1, J8.VIN, P2.A7, P2.B7, P2.C7
/Address Decoder & Wait States/AB5: P2.C9, RN501.11, U40.1
/Address Decoder & Wait States/AB6: P2.C10, RN501.10, U40.2
/Address Decoder & Wait States/AB7: P2.C11, RN501.9, U40.3
/Address Decoder & Wait States/FPA3: RN7.6, U3.16, U4.3, U34.2, U40.12, U1901.4, U1902.4, U1903.4, U1904.4
/Address Decoder & Wait States/FPA4: RN7.5, U3.15, U4.4, U34.3, U40.9, U1901.5, U1902.5, U1903.5, U1904.5
/Address Decoder & Wait States/FPA5: RN7.4, U3.14, U40.8, U1901.6, U1902.6, U1903.6, U1904.6
/Address Decoder & Wait States/FPA6: RN7.3, U3.13, U34.5, U40.7
/Address Decoder & Wait States/~DFPSEL: U40.19, U41.1
/BUSCP: J8.D42, RN402.2, U401.9, U1002.11, U1102.11, U1202.11, U1302.11, U1402.11
/Bus Connectors/AB0: P2.C4, RN501.16
/Bus Connectors/AB1: P2.A5, RN501.15
/Bus Connectors/AB2: P2.A6, RN501.14
/Bus Connectors/AB3: P2.C6, RN501.13
/Bus Connectors/AB4: P2.C8, RN501.12
/Bus Connectors/AB8: P2.C15, RN601.16
/Bus Connectors/AB9: P2.C16, RN601.15
/Bus Connectors/AB10: P2.C17, RN601.14
/Bus Connectors/AB11: P2.C18, RN601.13
/Bus Connectors/AB12: P2.C19, RN601.12
/Bus Connectors/AB13: P2.C20, RN601.11
/Bus Connectors/AB14: P2.C21, RN601.10
/Bus Connectors/AB15: P2.C22, RN601.9
/Bus Connectors/AB16: P2.B23, RN701.16
/Bus Connectors/AB17: P2.B24, RN701.15
/Bus Connectors/AB18: P2.B25, RN701.14
/Bus Connectors/AB19: P2.B26, RN701.13
/Bus Connectors/AB20: P2.B27, RN701.12
/Bus Connectors/AB21: P2.B28, RN701.11
/Bus Connectors/AB22: P2.B29, RN701.10
/Bus Connectors/AB23: P2.B30, RN701.9
/Bus Connectors/ACTION0: P1.B14, RN1301.16
/Bus Connectors/ACTION1: P1.B15, RN1301.15
/Bus Connectors/ACTION2: P1.B16, RN1301.14
/Bus Connectors/ACTION3: P1.B17, RN1301.13
/Bus Connectors/CFT-FPD0: P1.A23, RN1701.1, RN1702.2
/Bus Connectors/CFT-FPD1: P1.A24, RN1701.2, RN1702.3
/Bus Connectors/CFT-FPD2: P1.A25, RN1701.3, RN1702.4
/Bus Connectors/CFT-FPD3: P1.A26, RN1701.4, RN1702.5
/Bus Connectors/CFT-FPD4: P1.A27, RN1701.5, RN1702.6
/Bus Connectors/CFT-FPD5: P1.A28, RN1701.6, RN1702.7
/Bus Connectors/CFT-FPD6: P1.A29, RN1701.7, RN1702.8
/Bus Connectors/CFT-FPD7: P1.A30, RN1701.8, RN1702.9
/Bus Connectors/COND0: P1.B18, RN1301.12
/Bus Connectors/COND1: P1.B19, RN1301.11
/Bus Connectors/COND2: P1.B20, RN1301.10
/Bus Connectors/COND3: P1.B21, RN1301.9
/Bus Connectors/DB0: P2.A15, RN801.16
/Bus Connectors/DB1: P2.A16, RN801.15
/Bus Connectors/DB2: P2.A17, RN801.14
/Bus Connectors/DB3: P2.A18, RN801.13
/Bus Connectors/DB4: P2.A19, RN801.12
/Bus Connectors/DB5: P2.A20, RN801.11
/Bus Connectors/DB6: P2.A21, RN801.10
/Bus Connectors/DB7: P2.A22, RN801.9
/Bus Connectors/DB8: P2.A23, RN904.16
/Bus Connectors/DB9: P2.A24, RN904.15
/Bus Connectors/DB10: P2.A25, RN904.14
/Bus Connectors/DB11: P2.A26, RN904.13
/Bus Connectors/DB12: P2.A27, RN904.12
/Bus Connectors/DB13: P2.A28, RN904.11
/Bus Connectors/DB14: P2.A29, RN904.10
/Bus Connectors/DB15: P2.A30, RN904.9
/Bus Connectors/FP-FPD0: D17.1, J2.12, RN1703.16
/Bus Connectors/FP-FPD1: D18.2, J2.11, RN1703.15
/Bus Connectors/FP-FPD2: D17.2, J2.10, RN1703.14
/Bus Connectors/FP-FPD3: D18.1, J2.9, RN1703.13
/Bus Connectors/FP-FPD4: D19.1, J2.8, RN1703.12
/Bus Connectors/FP-FPD5: D20.2, J2.7, RN1703.11
/Bus Connectors/FP-FPD6: D19.2, J2.6, RN1703.10
/Bus Connectors/FP-FPD7: D20.1, J2.5, RN1703.9
/Bus Connectors/FPA0: J2.3, RN7.9, U3.19, U4.15, U301.1, U302.1, U303.1, U304.1, U1901.1, U1902.1, U1903.1, U1904.1
/Bus Connectors/FPA1: J2.4, RN7.8, U3.18, U4.1, U301.2, U302.2, U303.2, U304.2, U1901.2, U1902.2, U1903.2, U1904.2
/Bus Connectors/FPD0: U5.2, U28.18, U29.2, U38.18, U305.2, U305.19, U306.2, U306.19, U307.18, U308.18, U309.18, U501.2, U502.19, U601.2, U602.19, U701.2, U702.19, U801.2, U802.19, U901.2, U902.19, U1001.2, U1002.19, U1101.2, U1102.19, U1201.2, U1202.19, U1301.2, U1302.19, U1401.2, U1402.19
/Bus Connectors/FPD1: U5.3, U28.17, U29.3, U38.17, U305.3, U305.18, U306.3, U306.18, U307.17, U308.17, U309.17, U501.3, U502.18, U601.3, U602.18, U701.3, U702.18, U801.3, U802.18, U901.3, U902.18, U1001.3, U1002.18, U1101.3, U1102.18, U1201.3, U1202.18, U1301.3, U1302.18, U1401.3, U1402.18
/Bus Connectors/FPD2: U5.4, U28.16, U29.4, U38.16, U305.4, U305.17, U306.4, U306.17, U307.16, U308.16, U309.16, U501.4, U502.17, U601.4, U602.17, U701.4, U702.17, U801.4, U802.17, U901.4, U902.17, U1001.4, U1002.17, U1101.4, U1102.17, U1201.4, U1202.17, U1301.4, U1302.17, U1401.4, U1402.17
/Bus Connectors/FPD3: U5.5, U28.15, U29.5, U38.15, U305.5, U305.16, U306.5, U306.16, U307.15, U308.15, U309.15, U501.5, U502.16, U601.5, U602.16, U701.5, U702.16, U801.5, U802.16, U901.5, U902.16, U1001.5, U1002.16, U1101.5, U1102.16, U1201.5, U1202.16, U1301.5, U1302.16, U1401.5, U1402.16
/Bus Connectors/FPD4: U5.6, U28.14, U29.6, U38.14, U305.6, U305.15, U306.6, U306.15, U307.14, U308.14, U309.14, U501.6, U502.15, U601.6, U602.15, U701.6, U702.15, U801.6, U802.15, U901.6, U902.15, U1001.6, U1002.15, U1101.6, U1102.15, U1201.6, U1202.15, U1301.6, U1302.15, U1401.6, U1402.15
/Bus Connectors/FPD5: U5.7, U28.13, U29.7, U38.13, U305.7, U305.14, U306.7, U306.14, U307.13, U308.13, U309.13, U501.7, U502.14, U601.7, U602.14, U701.7, U702.14, U801.7, U802.14, U901.7, U902.14, U1001.7, U1002.14, U1101.7, U1102.14, U1201.7, U1202.14, U1301.7, U1302.14, U1401.7, U1402.14
/Bus Connectors/FPD6: U5.8, U28.12, U29.8, U38.12, U305.8, U305.13, U306.8, U306.13, U307.12, U308.12, U309.12, U501.8, U502.13, U601.8, U602.13, U701.8, U702.13, U801.8, U802.13, U901.8, U902.13, U1001.8, U1002.13, U1101.8, U1102.13, U1201.8, U1202.13, U1301.8, U1302.13, U1401.8, U1402.13
/Bus Connectors/FPD7: U5.9, U28.11, U29.9, U38.11, U305.9, U305.12, U306.9, U306.12, U307.11, U308.11, U309.11, U501.9, U502.12, U601.9, U602.12, U701.9, U702.12, U801.9, U802.12, U901.9, U902.12, U1001.9, U1002.12, U1101.9, U1102.12, U1201.9, U1202.12, U1301.9, U1302.12, U1401.9, U1402.12
/Bus Connectors/IBUS0: P1.C15, RN1001.16
/Bus Connectors/IBUS1: P1.C16, RN1001.15
/Bus Connectors/IBUS2: P1.C17, RN1001.14
/Bus Connectors/IBUS3: P1.C18, RN1001.13
/Bus Connectors/IBUS4: P1.C19, RN1001.12
/Bus Connectors/IBUS5: P1.C20, RN1001.11
/Bus Connectors/IBUS6: P1.C21, RN1001.10
/Bus Connectors/IBUS7: P1.C22, RN1001.9
/Bus Connectors/IBUS8: P1.C23, RN1101.16
/Bus Connectors/IBUS9: P1.C24, RN1101.15
/Bus Connectors/IBUS10: P1.C25, RN1101.14
/Bus Connectors/IBUS11: P1.C26, RN1101.13
/Bus Connectors/IBUS12: P1.C27, RN1101.12
/Bus Connectors/IBUS13: P1.C28, RN1101.11
/Bus Connectors/IBUS14: P1.C29, RN1101.10
/Bus Connectors/IBUS15: P1.C30, RN1101.9
/Bus Connectors/RADDR0: P1.C4, RN1401.16
/Bus Connectors/RADDR1: P1.C6, RN1401.15
/Bus Connectors/RADDR2: P1.B6, RN1401.14
/Bus Connectors/RADDR3: P1.B7, RN1401.13
/Bus Connectors/RADDR4: P1.B8, RN1401.12
/Bus Connectors/SWA0: J2.18, R1501.1
/Bus Connectors/SWA1: J2.19, R1502.1
/Bus Connectors/SWA2: J2.20, R1503.1
/Bus Connectors/SWA3: J2.21, R1504.1
/Bus Connectors/SWD0: J2.22, J8.A4
/Bus Connectors/SWD1: J2.23, J8.A5
/Bus Connectors/SWD2: J2.24, J8.A6
/Bus Connectors/SWD3: J2.25, J8.A7
/Bus Connectors/WADDR0: P1.B9, RN1201.16
/Bus Connectors/WADDR1: P1.B10, RN1201.15
/Bus Connectors/WADDR2: P1.B11, RN1201.14
/Bus Connectors/WADDR3: P1.B12, RN1201.13
/Bus Connectors/WADDR4: P1.B13, RN1201.12
/Bus Connectors/~ROW1: J2.13, R901.1
/Bus Connectors/~ROW2: J2.14, R902.1
/Bus Connectors/~ROW3: J2.15, R903.1
/Bus Connectors/~ROW4: J2.16, R904.1
/Bus Connectors/~ROW5: J2.17, R905.1
/Bus Pods/8-bit I/O Pod/D0: RN501.1, U501.19, U502.2
/Bus Pods/8-bit I/O Pod/D1: RN501.2, U501.18, U502.3
/Bus Pods/8-bit I/O Pod/D2: RN501.3, U501.17, U502.4
/Bus Pods/8-bit I/O Pod/D3: RN501.4, U501.16, U502.5
/Bus Pods/8-bit I/O Pod/D4: RN501.5, U501.15, U502.6
/Bus Pods/8-bit I/O Pod/D5: RN501.6, U501.14, U502.7
/Bus Pods/8-bit I/O Pod/D6: RN501.7, U501.13, U502.8
/Bus Pods/8-bit I/O Pod/D7: RN501.8, U501.12, U502.9
/Bus Pods/BPCP: U401.8, U502.11, U602.11, U702.11, U802.11, U902.11
/Bus Pods/sheet61D0EEB6/D0: RN601.1, U601.19, U602.2
/Bus Pods/sheet61D0EEB6/D1: RN601.2, U601.18, U602.3
/Bus Pods/sheet61D0EEB6/D2: RN601.3, U601.17, U602.4
/Bus Pods/sheet61D0EEB6/D3: RN601.4, U601.16, U602.5
/Bus Pods/sheet61D0EEB6/D4: RN601.5, U601.15, U602.6
/Bus Pods/sheet61D0EEB6/D5: RN601.6, U601.14, U602.7
/Bus Pods/sheet61D0EEB6/D6: RN601.7, U601.13, U602.8
/Bus Pods/sheet61D0EEB6/D7: RN601.8, U601.12, U602.9
/Bus Pods/sheet61D30C08/D0: RN701.1, U701.19, U702.2
/Bus Pods/sheet61D30C08/D1: RN701.2, U701.18, U702.3
/Bus Pods/sheet61D30C08/D2: RN701.3, U701.17, U702.4
/Bus Pods/sheet61D30C08/D3: RN701.4, U701.16, U702.5
/Bus Pods/sheet61D30C08/D4: RN701.5, U701.15, U702.6
/Bus Pods/sheet61D30C08/D5: RN701.6, U701.14, U702.7
/Bus Pods/sheet61D30C08/D6: RN701.7, U701.13, U702.8
/Bus Pods/sheet61D30C08/D7: RN701.8, U701.12, U702.9
/Bus Pods/sheet61FBB541/D0: RN801.1, U801.19, U802.2
/Bus Pods/sheet61FBB541/D1: RN801.2, U801.18, U802.3
/Bus Pods/sheet61FBB541/D2: RN801.3, U801.17, U802.4
/Bus Pods/sheet61FBB541/D3: RN801.4, U801.16, U802.5
/Bus Pods/sheet61FBB541/D4: RN801.5, U801.15, U802.6
/Bus Pods/sheet61FBB541/D5: RN801.6, U801.14, U802.7
/Bus Pods/sheet61FBB541/D6: RN801.7, U801.13, U802.8
/Bus Pods/sheet61FBB541/D7: RN801.8, U801.12, U802.9
/Bus Pods/sheet61FBB542/D0: RN904.1, U901.19, U902.2
/Bus Pods/sheet61FBB542/D1: RN904.2, U901.18, U902.3
/Bus Pods/sheet61FBB542/D2: RN904.3, U901.17, U902.4
/Bus Pods/sheet61FBB542/D3: RN904.4, U901.16, U902.5
/Bus Pods/sheet61FBB542/D4: RN904.5, U901.15, U902.6
/Bus Pods/sheet61FBB542/D5: RN904.6, U901.14, U902.7
/Bus Pods/sheet61FBB542/D6: RN904.7, U901.13, U902.8
/Bus Pods/sheet61FBB542/D7: RN904.8, U901.12, U902.9
/Bus Pods/sheet621C990A/D0: RN1301.1, U1301.19, U1302.2
/Bus Pods/sheet621C990A/D1: RN1301.2, U1301.18, U1302.3
/Bus Pods/sheet621C990A/D2: RN1301.3, U1301.17, U1302.4
/Bus Pods/sheet621C990A/D3: RN1301.4, U1301.16, U1302.5
/Bus Pods/sheet621C990A/D4: RN1301.5, U1301.15, U1302.6
/Bus Pods/sheet621C990A/D5: RN1301.6, U1301.14, U1302.7
/Bus Pods/sheet621C990A/D6: RN1301.7, U1301.13, U1302.8
/Bus Pods/sheet621C990A/D7: RN1301.8, U1301.12, U1302.9
/Bus Pods/sheet621C9908/D0: RN1401.1, U1401.19, U1402.2
/Bus Pods/sheet621C9908/D1: RN1401.2, U1401.18, U1402.3
/Bus Pods/sheet621C9908/D2: RN1401.3, U1401.17, U1402.4
/Bus Pods/sheet621C9908/D3: RN1401.4, U1401.16, U1402.5
/Bus Pods/sheet621C9908/D4: RN1401.5, U1401.15, U1402.6
/Bus Pods/sheet621C9908/D5: RN1401.6, U1401.14, U1402.7
/Bus Pods/sheet621C9908/D6: RN1401.7, U1401.13, U1402.8
/Bus Pods/sheet621C9908/D7: RN1401.8, U1401.12, U1402.9
/Bus Pods/sheet621C9909/D0: RN1201.1, U1201.19, U1202.2
/Bus Pods/sheet621C9909/D1: RN1201.2, U1201.18, U1202.3
/Bus Pods/sheet621C9909/D2: RN1201.3, U1201.17, U1202.4
/Bus Pods/sheet621C9909/D3: RN1201.4, U1201.16, U1202.5
/Bus Pods/sheet621C9909/D4: RN1201.5, U1201.15, U1202.6
/Bus Pods/sheet621C9909/D5: RN1201.6, U1201.14, U1202.7
/Bus Pods/sheet621C9909/D6: RN1201.7, U1201.13, U1202.8
/Bus Pods/sheet621C9909/D7: RN1201.8, U1201.12, U1202.9
/Bus Pods/sheet6215CD55/D0: RN1001.1, U1001.19, U1002.2
/Bus Pods/sheet6215CD55/D1: RN1001.2, U1001.18, U1002.3
/Bus Pods/sheet6215CD55/D2: RN1001.3, U1001.17, U1002.4
/Bus Pods/sheet6215CD55/D3: RN1001.4, U1001.16, U1002.5
/Bus Pods/sheet6215CD55/D4: RN1001.5, U1001.15, U1002.6
/Bus Pods/sheet6215CD55/D5: RN1001.6, U1001.14, U1002.7
/Bus Pods/sheet6215CD55/D6: RN1001.7, U1001.13, U1002.8
/Bus Pods/sheet6215CD55/D7: RN1001.8, U1001.12, U1002.9
/Bus Pods/sheet6215CD56/D0: RN1101.1, U1101.19, U1102.2
/Bus Pods/sheet6215CD56/D1: RN1101.2, U1101.18, U1102.3
/Bus Pods/sheet6215CD56/D2: RN1101.3, U1101.17, U1102.4
/Bus Pods/sheet6215CD56/D3: RN1101.4, U1101.16, U1102.5
/Bus Pods/sheet6215CD56/D4: RN1101.5, U1101.15, U1102.6
/Bus Pods/sheet6215CD56/D5: RN1101.6, U1101.14, U1102.7
/Bus Pods/sheet6215CD56/D6: RN1101.7, U1101.13, U1102.8
/Bus Pods/sheet6215CD56/D7: RN1101.8, U1101.12, U1102.9
/Bus Pods/~RAB0A: U401.3, U502.1
/Bus Pods/~RAB1A: U401.11, U602.1
/Bus Pods/~RAB2A: U402.3, U702.1
/Bus Pods/~RDB0A: U402.11, U802.1
/Bus Pods/~RDB1A: U401.6, U902.1
/CLK4: P1.C2, U201.5
/CLRWS: J8.A8, R1901.1, U41.13
/DFP I/O/FPA2: RN7.7, U3.17, U4.2, U34.1, U301.4, U302.3, U303.3, U304.3, U1901.3, U1902.3, U1903.3, U1904.3
/DFP I/O/~RDSR0: U302.15, U307.1
/DFP I/O/~RDSR1: U304.19, U308.1
/DFP I/O/~RDSR2: U304.18, U309.1
/DFP I/O/~WOR0: U302.19, U305.11
/DFP I/O/~WOR1: U302.18, U306.11
/FPCLKEN: P1.A3, R202.1
/FPCLKEN-IN: J8.D44, U201.4
/FPFETCH∕~EXEC: P1.A22, R206.1, U201.3, U202.3
/FPµSTEP: P1.C12, R201.1
/FPµSTEP-IN: J8.D43, RN402.1, U201.6
/MFD0: J8.D52, U1901.7, U1902.7, U1903.7, U1904.7
/MFD1: J8.D51, U1901.8, U1902.8, U1903.8, U1904.8
/MFD2: J8.D50, U1901.9, U1902.9, U1903.9, U1904.9
/Microcontroller/ACT-LED: J8.D46, R6.1
/Microcontroller/ALE: J8.D39, R4.1, U3.11
/Microcontroller/FPA7: RN7.2, U3.12, U34.4
/Microcontroller/MCD0: J8.D22, U3.2, U5.18
/Microcontroller/MCD1: J8.D23, U3.3, U5.17
/Microcontroller/MCD2: J8.D24, U3.4, U5.16
/Microcontroller/MCD3: J8.D25, U3.5, U5.15
/Microcontroller/MCD4: J8.D26, U3.6, U5.14
/Microcontroller/MCD5: J8.D27, U3.7, U5.13
/Microcontroller/MCD6: J8.D28, U3.8, U5.12
/Microcontroller/MCD7: J8.D29, U3.9, U5.11
/Microcontroller/PANEL-LED: J8.D48, R8.1
/Microcontroller/RXD: JP9.2, R1.2
/Microcontroller/RXDA: J8.D19, JP9.1
/Microcontroller/RXDB: J8.D15, JP9.3
/Microcontroller/SCANCLK: JP501.2, U4.11, U4.13
/Microcontroller/SPARE: R39.1, TP3.1
/Microcontroller/TXD: JP7.2, R5.2
/Microcontroller/TXDA: J8.D18, JP7.1
/Microcontroller/TXDB: J8.D14, JP7.3
/Microcontroller/~BUSEN: J8.D37, RN401.2, U3.1, U5.19
/Microcontroller/~µCIO: J8.D31, RN4.2
/Microcontroller/~µCMEM: J8.D30, RN4.1
/Microcontroller/~µCR: J8.D32, RN4.3
/Microcontroller/~µCW: J8.D33, RN4.4
/Microcontroller/µCSCANCLK: J8.D11, JP501.3, R402.2
/ROWEN: U34.6, U301.19
/Run Control State Machine/CLK4-A: U201.16, U202.11
/Run Control State Machine/LED-WAIT: R2.1, U201.12
/Run Control State Machine/STEPPING: U201.15, U202.5
/Run Control State Machine/µSTEPPING: U201.7, U202.9
/STEP∕~RUN: J8.D5, R203.2, U38.2, U202.4
/WAIT: J8.D20, U201.19
/sheet65BD1B09/~FPSTATE: U38.1, U1904.12
/~ABOE: J8.A10, R10.2, U501.1, U601.1, U701.1
/~AUTOSCAN: J8.D36, RN401.1, U4.14, U301.3
/~CLR: J8.D49, R205.2, U202.1, U202.13
/~CVOE: J8.A12, R12.1, U1201.1, U1301.1, U1401.1
/~DBOE0: J8.A11, U40.5
/~DBOE1: U40.13, U801.11, U901.1
/~EN0: U40.17, U301.5, U302.4, U303.4, U304.4
/~EN1: U40.16, U301.6, U302.5, U303.5, U304.5
/~FPABH: U402.2, U1904.16
/~FPABL: U401.2, U1904.18
/~FPABM: U401.13, U1904.17
/~FPACH: P1.A18, U1902.13
/~FPACL: P1.A10, U1901.13
/~FPAEXT: P1.A14, U1902.17
/~FPCTX: P1.A4, U1901.19
/~FPDBH: U401.5, U1904.15
/~FPDBL: U402.13, U1904.19
/~FPDRH: P1.A20, U1903.18
/~FPDRL: P1.A19, U1903.19
/~FPFLAGS: P1.A13, U1902.18
/~FPIEN: P1.B23, U1903.17
/~FPIRF: P1.B24, U1903.16
/~FPIRH: P1.A12, U1902.19
/~FPIRL: P1.A5, U1901.18
/~FPIRQ: JP3.1, JP3.3, JP3.5, R37.2
/~FPORH: U306.1, U1904.13
/~FPORL: U305.1, U1904.14
/~FPPCH: P1.A16, U1902.15
/~FPPCL: P1.A15, U1902.16
/~FPRAM~∕ROM: J8.D45, P1.A21
/~FPRSVD0: P1.B25, U1903.15
/~FPRSVD1: P1.B26, U1903.14
/~FPRSVD2: P1.B27, U1903.13
/~FPRSVD3: P1.B28, U1903.12
/~FPSPH: P1.A17, U1902.14
/~FPSPL: P1.A9, U1901.14
/~FPµA0: P1.A6, U1901.17
/~FPµC0: P1.A7, U1901.16
/~FPµC1: P1.A8, U1901.15
/~FPµC2: P1.A11, U1901.12
/~HALT: P2.B3, R38.1
/~IBOE: J8.A9, R13.1, U1001.11, U1101.11
/~IO: P2.B11, RN4.7
/~IODEV1XX: P2.A13, U40.4
/~IOINT: J8.D21, U41.6, U41.10
/~IRQ5: JP3.2, P2.C28
/~IRQ6: JP3.4, P2.C29
/~IRQ7: JP3.6, P2.C30
/~IRQS: P2.C14, U38.9
/~LED-EXEC: U38.6, U201.13
/~LED-FETCH: U38.5, U201.14
/~LED-STOP: J8.D10, R7.1, U38.3
/~LTSON: J2.26, R3.2
/~MEM: P2.B10, RN4.8
/~PANELEN: J8.D35, RN401.4, U28.1, U1901.11, U1902.11, U1903.11, U1904.11
/~R: P2.C12, RN4.6, U40.6
/~RAB0: U303.18, U401.1
/~RAB1: U303.17, U401.12
/~RAB2: U303.16, U402.1
/~RCV0: U304.14, U1402.1
/~RCV1: U304.12, U1202.1
/~RCV2: U304.15, U1302.1
/~RD: J8.D40, RN402.3, U301.9, U302.9, U303.9, U304.9
/~RDB0: U303.19, U402.12
/~RDB1: U303.15, U401.4
/~RESET: P2.A3, R40.1, U201.1
/~RIB0: U303.14, U1002.1
/~RIB1: U303.13, U1102.1
/~RSTHOLD: P2.C3, R41.1, U38.8, U201.2
/~SCANCLR: U4.10, U401.10, U1902.12
/~W: P2.C13, RN4.5
/~WAB0: U301.18, U501.11
/~WAB1: U301.17, U601.11
/~WAB2: U301.15, U701.11
/~WCV0: U302.14, U1401.11
/~WCV1: U302.13, U1201.11
/~WCV2: U302.12, U1301.11
/~WDB0: U301.14, U801.1
/~WDB1: U301.12, U901.11
/~WIB0: U301.16, U1001.1
/~WIB1: U301.13, U1101.1
/~WR: J8.D41, RN402.4, U5.1, U301.8, U302.8, U303.8, U304.8
/~WS: P2.C5, R36.1, U38.4
/~µSTEP: J8.D2, R204.2, U202.10
GND: C3.2, C4.2, C5.2, C11.2, C12.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C28.2, C29.2, C34.2, C38.2, C40.1, C41.1, C43.2, C101.2, C104.2, C106.2, C109.2, C113.2, C201.2, C202.2, C301.2, C302.2, C303.2, C304.2, C305.2, C306.2, C307.2, C308.2, C309.2, C401.2, C402.2, C501.2, C502.2, C601.2, C602.2, C701.2, C702.2, C801.2, C802.2, C901.2, C902.2, C1001.2, C1002.2, C1101.2, C1102.2, C1201.2, C1202.2, C1301.2, C1302.2, C1401.2, C1402.2, C1901.2, C1902.2, C1903.2, C1904.2, D1.1, D2.1, D3.1, D4.1, D17.3, D18.3, D19.3, D20.3, D2001.1, J1.1, J2.28, J2.29, J2.30, J8.GND1, J8.GND2, J8.GND3, J8.GND4, J8.GND5, J8.GND6, P1.A31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
unnamed: D1.2, R2.2
unnamed: D2.2, R7.2
unnamed: D3.2, R8.2
unnamed: D4.2, R6.2
unnamed: D2001.2, R2001.1
unnamed: J1.4, JP1.3, JP2.3
unnamed: J1.5, JP1.1, JP2.1
unnamed: J8.5V1, J8.5V2, J8.5V3, J8.5V4
unnamed: J8.A0, R1501.2
unnamed: J8.A1, R1502.2
unnamed: J8.A2, R1503.2
unnamed: J8.A3, R1504.2
unnamed: J8.D6, R38.2
unnamed: J8.D7, R39.2
unnamed: J8.D8, R40.2
unnamed: J8.D9, R41.2
unnamed: J8.D12, R3.1
unnamed: J8.D53, R37.1
unnamed: J8.RST1, SW1.1
unnamed: JP1.2, R5.1
unnamed: JP2.2, R1.1
unnamed: JP501.1, X1.5
unnamed: R14.1, U41.7, U43.2
unnamed: R14.2, U41.15
unnamed: R36.2, U43.4
unnamed: R201.2, U201.18
unnamed: R202.2, U201.17
unnamed: R901.2, U34.15
unnamed: R902.2, U34.14
unnamed: R903.2, U34.13
unnamed: R904.2, U34.12
unnamed: R905.2, U34.11
unnamed: R2001.2, U41.9
unnamed: RN15.2, SW2.16, U307.2
unnamed: RN15.3, SW2.15, U307.3
unnamed: RN15.4, SW2.14, U307.4
unnamed: RN15.5, SW2.13, U307.5
unnamed: RN15.6, SW2.12, U307.6
unnamed: RN15.7, SW2.11, U307.7
unnamed: RN15.8, SW2.10, U307.8
unnamed: RN15.9, SW2.9, U307.9
unnamed: RN16.2, SW3.16, U308.2
unnamed: RN16.3, SW3.15, U308.3
unnamed: RN16.4, SW3.14, U308.4
unnamed: RN16.5, SW3.13, U308.5
unnamed: RN16.6, SW3.12, U308.6
unnamed: RN16.7, SW3.11, U308.7
unnamed: RN16.8, SW3.10, U308.8
unnamed: RN16.9, SW3.9, U308.9
unnamed: RN17.2, SW4.16, U309.2
unnamed: RN17.3, SW4.15, U309.3
unnamed: RN17.4, SW4.14, U309.4
unnamed: RN17.5, SW4.13, U309.5
unnamed: RN17.6, SW4.12, U309.6
unnamed: RN17.7, SW4.11, U309.7
unnamed: RN17.8, SW4.10, U309.8
unnamed: RN17.9, SW4.9, U309.9
unnamed: RN1701.9, U28.9
unnamed: RN1701.10, U28.8
unnamed: RN1701.11, U28.7
unnamed: RN1701.12, U28.6
unnamed: RN1701.13, U28.5
unnamed: RN1701.14, U28.4
unnamed: RN1701.15, U28.3
unnamed: RN1701.16, U28.2
unnamed: RN1703.1, U29.18
unnamed: RN1703.2, U29.17
unnamed: RN1703.3, U29.16
unnamed: RN1703.4, U29.15
unnamed: RN1703.5, U29.14
unnamed: RN1703.6, U29.13
unnamed: RN1703.7, U29.12
unnamed: RN1703.8, U29.11

Notices in the files:
kicad/cft/cft-backplane/cft-backplane-peripheral.kicad_pcb:
© 2001–2021 Alexios Chouchoulas
