# Repository alexiosc/cft (continued)

## KiCad design kicad/cft/cft-backplane/cft-backplane-processor.kicad_pcb (continued)

Parts:
H1, H2: MountingHole_Pad; MountingHole_2.7mm_M2.5_ISO14580_Pad
J5: DIN-41612-3x32-Bauform-C; DIN41612_C_3x32_Female_Vertical_THT

Connections:
+5V: J5.A1, J5.B1, J5.C1; also elsewhere on the board
/A2: J5.A2; also elsewhere on the board
/A23: J5.A23; also elsewhere on the board
/A24: J5.A24; also elsewhere on the board
/A25: J5.A25; also elsewhere on the board
/A26: J5.A26; also elsewhere on the board
/A27: J5.A27; also elsewhere on the board
/A28: J5.A28; also elsewhere on the board
/A29: J5.A29; also elsewhere on the board
/A30: J5.A30; also elsewhere on the board
/ACTION0: J5.B14; also elsewhere on the board
/ACTION1: J5.B15; also elsewhere on the board
/ACTION2: J5.B16; also elsewhere on the board
/ACTION3: J5.B17; also elsewhere on the board
/B2: J5.B2; also elsewhere on the board
/B3: J5.B3; also elsewhere on the board
/B6: J5.B6; also elsewhere on the board
/B7: J5.B7; also elsewhere on the board
/B8: J5.B8; also elsewhere on the board
/B9: J5.B9; also elsewhere on the board
/B10: J5.B10; also elsewhere on the board
/B11: J5.B11; also elsewhere on the board
/B12: J5.B12; also elsewhere on the board
/B13: J5.B13; also elsewhere on the board
/B18: J5.B18; also elsewhere on the board
/B19: J5.B19; also elsewhere on the board
/B20: J5.B20; also elsewhere on the board
/B21: J5.B21; also elsewhere on the board
/B22: J5.B22; also elsewhere on the board
/C2: J5.C2; also elsewhere on the board
/C3: J5.C3; also elsewhere on the board
/C4: J5.C4; also elsewhere on the board
/C6: J5.C6; also elsewhere on the board
/C7: J5.C7; also elsewhere on the board
/C8: J5.C8; also elsewhere on the board
/C9: J5.C9; also elsewhere on the board
/C10: J5.C10; also elsewhere on the board
/C11: J5.C11; also elsewhere on the board
/C13: J5.C13; also elsewhere on the board
/C14: J5.C14; also elsewhere on the board
/C15: J5.C15; also elsewhere on the board
/C16: J5.C16; also elsewhere on the board
/C17: J5.C17; also elsewhere on the board
/C18: J5.C18; also elsewhere on the board
/C19: J5.C19; also elsewhere on the board
/C20: J5.C20; also elsewhere on the board
/C21: J5.C21; also elsewhere on the board
/C22: J5.C22; also elsewhere on the board
/C23: J5.C23; also elsewhere on the board
/C24: J5.C24; also elsewhere on the board
/C25: J5.C25; also elsewhere on the board
/C26: J5.C26; also elsewhere on the board
/C27: J5.C27; also elsewhere on the board
/C28: J5.C28; also elsewhere on the board
/C29: J5.C29; also elsewhere on the board
/C30: J5.C30; also elsewhere on the board
GND: H1.1, H2.1, J5.A31, J5.A32, J5.B4, J5.B5, J5.B31, J5.B32, J5.C31, J5.C32; also elsewhere on the board

Parts of its further copies:
H3, H4, H5, H6, H7, H8, H9, H10, H11, H12, H13, H14, H15, H16, H17, H18, H19, H20, H21, H22, H23, H24: MountingHole_Pad; MountingHole_2.7mm_M2.5_ISO14580_Pad
J1, J2, J3, J4, J6, J7, J8, J9, J10, J11, J12: DIN-41612-3x32-Bauform-C; DIN41612_C_3x32_Female_Vertical_THT

Connections of its further copies:
+5V: J1.A1, J1.B1, J1.C1, J2.A1, J2.B1, J2.C1, J3.A1, J3.B1, J3.C1, J4.A1, J4.B1, J4.C1, J6.A1, J6.B1, J6.C1, J7.A1, J7.B1, J7.C1, J8.A1, J8.B1, J8.C1, J9.A1, J9.B1, J9.C1, J10.A1, J10.B1, J10.C1, J11.A1, J11.B1, J11.C1, J12.A1, J12.B1, J12.C1; also elsewhere on the board
/A2: J1.A2, J2.A2, J3.A2, J4.A2, J6.A2, J7.A2, J8.A2, J9.A2, J10.A2, J11.A2, J12.A2; also elsewhere on the board
/A23: J1.A23, J2.A23, J3.A23, J4.A23, J6.A23, J7.A23, J8.A23, J9.A23, J10.A23, J11.A23, J12.A23; also elsewhere on the board
/A24: J1.A24, J2.A24, J3.A24, J4.A24, J6.A24, J7.A24, J8.A24, J9.A24, J10.A24, J11.A24, J12.A24; also elsewhere on the board
/A25: J1.A25, J2.A25, J3.A25, J4.A25, J6.A25, J7.A25, J8.A25, J9.A25, J10.A25, J11.A25, J12.A25; also elsewhere on the board
/A26: J1.A26, J2.A26, J3.A26, J4.A26, J6.A26, J7.A26, J8.A26, J9.A26, J10.A26, J11.A26, J12.A26; also elsewhere on the board
/A27: J1.A27, J2.A27, J3.A27, J4.A27, J6.A27, J7.A27, J8.A27, J9.A27, J10.A27, J11.A27, J12.A27; also elsewhere on the board
/A28: J1.A28, J2.A28, J3.A28, J4.A28, J6.A28, J7.A28, J8.A28, J9.A28, J10.A28, J11.A28, J12.A28; also elsewhere on the board
/A29: J1.A29, J2.A29, J3.A29, J4.A29, J6.A29, J7.A29, J8.A29, J9.A29, J10.A29, J11.A29, J12.A29; also elsewhere on the board
/A30: J1.A30, J2.A30, J3.A30, J4.A30, J6.A30, J7.A30, J8.A30, J9.A30, J10.A30, J11.A30, J12.A30; also elsewhere on the board
/ACTION0: J1.B14, J2.B14, J3.B14, J4.B14, J6.B14, J7.B14, J8.B14, J9.B14, J10.B14, J11.B14, J12.B14; also elsewhere on the board
/ACTION1: J1.B15, J2.B15, J3.B15, J4.B15, J6.B15, J7.B15, J8.B15, J9.B15, J10.B15, J11.B15, J12.B15; also elsewhere on the board
/ACTION2: J1.B16, J2.B16, J3.B16, J4.B16, J6.B16, J7.B16, J8.B16, J9.B16, J10.B16, J11.B16, J12.B16; also elsewhere on the board
/ACTION3: J1.B17, J2.B17, J3.B17, J4.B17, J6.B17, J7.B17, J8.B17, J9.B17, J10.B17, J11.B17, J12.B17; also elsewhere on the board
/B2: J1.B2, J2.B2, J3.B2, J4.B2, J6.B2, J7.B2, J8.B2, J9.B2, J10.B2, J11.B2, J12.B2; also elsewhere on the board
/B3: J1.B3, J2.B3, J3.B3, J4.B3, J6.B3, J7.B3, J8.B3, J9.B3, J10.B3, J11.B3, J12.B3; also elsewhere on the board
/B6: J1.B6, J2.B6, J3.B6, J4.B6, J6.B6, J7.B6, J8.B6, J9.B6, J10.B6, J11.B6, J12.B6; also elsewhere on the board
/B7: J1.B7, J2.B7, J3.B7, J4.B7, J6.B7, J7.B7, J8.B7, J9.B7, J10.B7, J11.B7, J12.B7; also elsewhere on the board
/B8: J1.B8, J2.B8, J3.B8, J4.B8, J6.B8, J7.B8, J8.B8, J9.B8, J10.B8, J11.B8, J12.B8; also elsewhere on the board
/B9: J1.B9, J2.B9, J3.B9, J4.B9, J6.B9, J7.B9, J8.B9, J9.B9, J10.B9, J11.B9, J12.B9; also elsewhere on the board
/B10: J1.B10, J2.B10, J3.B10, J4.B10, J6.B10, J7.B10, J8.B10, J9.B10, J10.B10, J11.B10, J12.B10; also elsewhere on the board
/B11: J1.B11, J2.B11, J3.B11, J4.B11, J6.B11, J7.B11, J8.B11, J9.B11, J10.B11, J11.B11, J12.B11; also elsewhere on the board
/B12: J1.B12, J2.B12, J3.B12, J4.B12, J6.B12, J7.B12, J8.B12, J9.B12, J10.B12, J11.B12, J12.B12; also elsewhere on the board
/B13: J1.B13, J2.B13, J3.B13, J4.B13, J6.B13, J7.B13, J8.B13, J9.B13, J10.B13, J11.B13, J12.B13; also elsewhere on the board
/B18: J1.B18, J2.B18, J3.B18, J4.B18, J6.B18, J7.B18, J8.B18, J9.B18, J10.B18, J11.B18, J12.B18; also elsewhere on the board
/B19: J1.B19, J2.B19, J3.B19, J4.B19, J6.B19, J7.B19, J8.B19, J9.B19, J10.B19, J11.B19, J12.B19; also elsewhere on the board
/B20: J1.B20, J2.B20, J3.B20, J4.B20, J6.B20, J7.B20, J8.B20, J9.B20, J10.B20, J11.B20, J12.B20; also elsewhere on the board
/B21: J1.B21, J2.B21, J3.B21, J4.B21, J6.B21, J7.B21, J8.B21, J9.B21, J10.B21, J11.B21, J12.B21; also elsewhere on the board
/B22: J1.B22, J2.B22, J3.B22, J4.B22, J6.B22, J7.B22, J8.B22, J9.B22, J10.B22, J11.B22, J12.B22; also elsewhere on the board
/C2: J1.C2, J2.C2, J3.C2, J4.C2, J6.C2, J7.C2, J8.C2, J9.C2, J10.C2, J11.C2, J12.C2; also elsewhere on the board
/C3: J1.C3, J2.C3, J3.C3, J4.C3, J6.C3, J7.C3, J8.C3, J9.C3, J10.C3, J11.C3, J12.C3; also elsewhere on the board
/C4: J1.C4, J2.C4, J3.C4, J4.C4, J6.C4, J7.C4, J8.C4, J9.C4, J10.C4, J11.C4, J12.C4; also elsewhere on the board
/C6: J1.C6, J2.C6, J3.C6, J4.C6, J6.C6, J7.C6, J8.C6, J9.C6, J10.C6, J11.C6, J12.C6; also elsewhere on the board
/C7: J1.C7, J2.C7, J3.C7, J4.C7, J6.C7, J7.C7, J8.C7, J9.C7, J10.C7, J11.C7, J12.C7; also elsewhere on the board
/C8: J1.C8, J2.C8, J3.C8, J4.C8, J6.C8, J7.C8, J8.C8, J9.C8, J10.C8, J11.C8, J12.C8; also elsewhere on the board
/C9: J1.C9, J2.C9, J3.C9, J4.C9, J6.C9, J7.C9, J8.C9, J9.C9, J10.C9, J11.C9, J12.C9; also elsewhere on the board
/C10: J1.C10, J2.C10, J3.C10, J4.C10, J6.C10, J7.C10, J8.C10, J9.C10, J10.C10, J11.C10, J12.C10; also elsewhere on the board
/C11: J1.C11, J2.C11, J3.C11, J4.C11, J6.C11, J7.C11, J8.C11, J9.C11, J10.C11, J11.C11, J12.C11; also elsewhere on the board
/C13: J1.C13, J2.C13, J3.C13, J4.C13, J6.C13, J7.C13, J8.C13, J9.C13, J10.C13, J11.C13, J12.C13; also elsewhere on the board
/C14: J1.C14, J2.C14, J3.C14, J4.C14, J6.C14, J7.C14, J8.C14, J9.C14, J10.C14, J11.C14, J12.C14; also elsewhere on the board
/C15: J1.C15, J2.C15, J3.C15, J4.C15, J6.C15, J7.C15, J8.C15, J9.C15, J10.C15, J11.C15, J12.C15; also elsewhere on the board
/C16: J1.C16, J2.C16, J3.C16, J4.C16, J6.C16, J7.C16, J8.C16, J9.C16, J10.C16, J11.C16, J12.C16; also elsewhere on the board
/C17: J1.C17, J2.C17, J3.C17, J4.C17, J6.C17, J7.C17, J8.C17, J9.C17, J10.C17, J11.C17, J12.C17; also elsewhere on the board
/C18: J1.C18, J2.C18, J3.C18, J4.C18, J6.C18, J7.C18, J8.C18, J9.C18, J10.C18, J11.C18, J12.C18; also elsewhere on the board
/C19: J1.C19, J2.C19, J3.C19, J4.C19, J6.C19, J7.C19, J8.C19, J9.C19, J10.C19, J11.C19, J12.C19; also elsewhere on the board
/C20: J1.C20, J2.C20, J3.C20, J4.C20, J6.C20, J7.C20, J8.C20, J9.C20, J10.C20, J11.C20, J12.C20; also elsewhere on the board
/C21: J1.C21, J2.C21, J3.C21, J4.C21, J6.C21, J7.C21, J8.C21, J9.C21, J10.C21, J11.C21, J12.C21; also elsewhere on the board
/C22: J1.C22, J2.C22, J3.C22, J4.C22, J6.C22, J7.C22, J8.C22, J9.C22, J10.C22, J11.C22, J12.C22; also elsewhere on the board
/C23: J1.C23, J2.C23, J3.C23, J4.C23, J6.C23, J7.C23, J8.C23, J9.C23, J10.C23, J11.C23, J12.C23; also elsewhere on the board
/C24: J1.C24, J2.C24, J3.C24, J4.C24, J6.C24, J7.C24, J8.C24, J9.C24, J10.C24, J11.C24, J12.C24; also elsewhere on the board
/C25: J1.C25, J2.C25, J3.C25, J4.C25, J6.C25, J7.C25, J8.C25, J9.C25, J10.C25, J11.C25, J12.C25; also elsewhere on the board
/C26: J1.C26, J2.C26, J3.C26, J4.C26, J6.C26, J7.C26, J8.C26, J9.C26, J10.C26, J11.C26, J12.C26; also elsewhere on the board
/C27: J1.C27, J2.C27, J3.C27, J4.C27, J6.C27, J7.C27, J8.C27, J9.C27, J10.C27, J11.C27, J12.C27; also elsewhere on the board
/C28: J1.C28, J2.C28, J3.C28, J4.C28, J6.C28, J7.C28, J8.C28, J9.C28, J10.C28, J11.C28, J12.C28; also elsewhere on the board
/C29: J1.C29, J2.C29, J3.C29, J4.C29, J6.C29, J7.C29, J8.C29, J9.C29, J10.C29, J11.C29, J12.C29; also elsewhere on the board
/C30: J1.C30, J2.C30, J3.C30, J4.C30, J6.C30, J7.C30, J8.C30, J9.C30, J10.C30, J11.C30, J12.C30; also elsewhere on the board
GND: H3.1, H4.1, H5.1, H6.1, H7.1, H8.1, H9.1, H10.1, H11.1, H12.1, H13.1, H14.1, H15.1, H16.1, H17.1, H18.1, H19.1, H20.1, H21.1, H22.1, H23.1, H24.1, J1.A31, J1.A32, J1.B4, J1.B5, J1.B31, J1.B32, J1.C31, J1.C32, J2.A31, J2.A32, J2.B4, J2.B5, J2.B31, J2.B32, J2.C31, J2.C32, J3.A31, J3.A32, J3.B4, J3.B5, J3.B31, J3.B32, J3.C31, J3.C32, J4.A31, J4.A32, J4.B4, J4.B5, J4.B31, J4.B32, J4.C31, J4.C32, J6.A31, J6.A32, J6.B4, J6.B5, J6.B31, J6.B32, J6.C31, J6.C32, J7.A31, J7.A32, J7.B4, J7.B5, J7.B31, J7.B32, J7.C31, J7.C32, J8.A31, J8.A32, J8.B4, J8.B5, J8.B31, J8.B32, J8.C31, J8.C32, J9.A31, J9.A32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; also elsewhere on the board

Board: 2 copper layers, 295.2 x 128.6 mm, 68 parts (9 on the bottom side), 59 nets.

## KiCad design kicad/cft/cft-backplane/cft-backplane.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10: 47µF; CP_Radial_D6.3mm_P2.50mm
C11, C12, C13, C14, C15, C16: 100nF; C_SMD_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1, D2, D3: LED_ALT; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D4: D_Schottky_ALT; SOD-323
J13: Phoenix 1766204; PhoenixContact_MC_1,5_10-G-3.81_1x10_P3.81mm_Horizontal; Mouser 651-1766204; €4.65
J14: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
P1: CFT-2021-Processor-Bus; DIN41612_B_3x32_Horizontal
P2: CFT-2021-Peripheral-Bus; DIN41612_B_3x32_Horizontal
R1, R2, R3: 1kΩ; R_SMD_0805_2012Metric_Pad1.15x1.40mm_HandSolder
TP1: TestPoint; TestPoint_Loop_D3.50mm_Drill1.4mm_Beaded
U1, U2, U3, U4, U5, U6: SN74ACT1071; SOIC-14

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, J13.8, J13.9, J13.10, P1.A1 (+5V), P1.B1 (+5V), P1.C1 (+5V), P2.A1 (+5V), P2.A2 (+5V), P2.B1 (+5V), P2.B2 (+5V), P2.C1 (+5V), P2.C2 (+5V), R1.2, U1.10 (VCC), U1.11 (VCC), U2.10 (VCC), U2.11 (VCC), U3.10 (VCC), U3.11 (VCC), U4.10 (VCC), U4.11 (VCC), U5.10 (VCC), U5.11 (VCC), U6.10 (VCC), U6.11 (VCC); also elsewhere on the board
/16MHz: P1.C5 (CLK)
/A3: D4.1 (K); also elsewhere on the board
/A25: U6.1 (D1); also elsewhere on the board
/A26: U6.2 (D2); also elsewhere on the board
/A27: U6.13 (D9); also elsewhere on the board
/A28: U6.12 (D8); also elsewhere on the board
/A29: U6.7 (D5); also elsewhere on the board
/A30: U6.8 (D6); also elsewhere on the board
/AB0: P2.C4 (AB0)
/AB1: P2.C5 (~WS)
/AB2: P2.C6 (AB3)
/AB3: P2.A7 (+12V), P2.B7 (+12V), P2.C7 (+12V)
/AB4: P2.C8 (AB4)
/AB5: P2.C9 (AB5)
/AB6: P2.C10 (AB6)
/AB7: P2.C11 (AB7)
/AB8: P2.C15 (AB8)
/AB9: P2.C16 (AB9)
/AB10: P2.C17 (AB10)
/AB11: P2.C18 (AB11)
/AB12: P2.C19 (AB12)
/AB13: P2.C20 (AB13)
/AB14: P2.C21 (AB14)
/AB15: P2.C22 (AB15)
/AB16: P2.B23 (AB16)
/AB17: P2.B24 (AB17)
/AB18: P2.B25 (AB18)
/AB19: P2.B26 (AB19)
/AB20: P2.B27 (AB20)
/AB21: P2.B28 (AB21)
/AB22: P2.B29 (AB22)
/AB23: P2.B30 (AB23)
/ACTION0: P1.B14 (ACTION0)
/ACTION1: P1.B15 (ACTION1)
/ACTION2: P1.B16 (ACTION2)
/ACTION3: P1.B17 (ACTION3)
/B6: U1.13 (D9); also elsewhere on the board
/B7: U1.12 (D8); also elsewhere on the board
/B8: U1.9 (D7); also elsewhere on the board
/B9: U1.8 (D6); also elsewhere on the board
/B10: U2.1 (D1); also elsewhere on the board
/B11: U2.2 (D2); also elsewhere on the board
/B12: U2.12 (D8); also elsewhere on the board
/B13: U2.9 (D7); also elsewhere on the board
/B14: U2.8 (D6); also elsewhere on the board
/B15: U3.1 (D1); also elsewhere on the board
/B16: U3.2 (D2); also elsewhere on the board
/B17: U3.12 (D8); also elsewhere on the board
/B18: U3.9 (D7); also elsewhere on the board
/B19: U3.8 (D6); also elsewhere on the board
/B20: U4.1 (D1); also elsewhere on the board
/B21: U4.2 (D2); also elsewhere on the board
/B22: U4.12 (D8); also elsewhere on the board
/B23: U4.9 (D7); also elsewhere on the board
/B24: U4.6 (D4); also elsewhere on the board
/B25: U4.8 (D6); also elsewhere on the board
/B26: U4.7 (D5); also elsewhere on the board
/B27: U6.14 (D10); also elsewhere on the board
/B28: U6.5 (D3); also elsewhere on the board
/B29: U6.6 (D4); also elsewhere on the board
/B30: U6.9 (D7); also elsewhere on the board
/C4: U1.14 (D10); also elsewhere on the board
/C5: U1.1 (D1); also elsewhere on the board
/C6: U1.2 (D2); also elsewhere on the board
/C7: U1.5 (D3); also elsewhere on the board
/C8: U1.6 (D4); also elsewhere on the board
/C9: U1.7 (D5); also elsewhere on the board
/C10: U2.14 (D10); also elsewhere on the board
/C11: U2.13 (D9); also elsewhere on the board
/C12: U2.5 (D3); also elsewhere on the board
/C13: U2.6 (D4); also elsewhere on the board
/C14: U2.7 (D5); also elsewhere on the board
/C15: U3.14 (D10); also elsewhere on the board
/C16: U3.13 (D9); also elsewhere on the board
/C17: U3.5 (D3); also elsewhere on the board
/C18: U3.6 (D4); also elsewhere on the board
/C19: U3.7 (D5); also elsewhere on the board
/C20: U4.14 (D10); also elsewhere on the board
/C21: U4.13 (D9); also elsewhere on the board
/C22: U4.5 (D3); also elsewhere on the board
/C23: U5.1 (D1); also elsewhere on the board
/C24: U5.14 (D10); also elsewhere on the board
/C25: U5.13 (D9); also elsewhere on the board
/C26: U5.2 (D2); also elsewhere on the board
/C27: U5.12 (D8); also elsewhere on the board
/C28: U5.9 (D7); also elsewhere on the board
/C29: U5.8 (D6); also elsewhere on the board
/C30: U5.7 (D5); also elsewhere on the board
/CLK1: P1.A2 (CLK1)
/CLK2: P1.B3 (CLK2)
/CLK3: P1.B2 (CLK3)
/CLK4: P1.C2 (CLK4)
/COND0: P1.B18 (COND0)
/COND1: P1.B19 (COND1)
/COND2: P1.B20 (COND2)
/COND3: P1.B21 (COND3)
/DB0: P2.A15 (DB0)
/DB1: P2.A16 (DB1)
/DB2: P2.A17 (DB2)
/DB3: P2.A18 (DB3)
/DB4: P2.A19 (DB4)
/DB5: P2.A20 (DB5)
/DB6: P2.A21 (DB6)
/DB7: P2.A22 (DB7)
/DB8: P2.A23 (DB8)
/DB9: P2.A24 (DB9)
/DB10: P2.A25 (DB10)
/DB11: P2.A26 (DB11)
/DB12: P2.A27 (DB12)
/DB13: P2.A28 (DB13)
/DB14: P2.A29 (DB14)
/DB15: P2.A30 (DB15)
/FL: P1.C8 (FL)
/FN: P1.C10 (FN)
/FPCLK: P1.A4 (UB3)
/FPD0: P1.A23 (FPD0)
/FPD1: P1.A24 (FPD1)
/FPD2: P1.A25 (FPD2)
/FPD3: P1.A26 (FPD3)
/FPD4: P1.A27 (FPD4)
/FPD5: P1.A28 (FPD5)
/FPD6: P1.A29 (FPD6)
/FPD7: P1.A30 (FPD7)
/FPFETCH: P1.A20 (UB19)
/FV: P1.C7 (FV)
/FZ: P1.C9 (FZ)
/IBUS0: P1.C15 (IBUS0)
/IBUS1: P1.C16 (IBUS1)
/IBUS2: P1.C17 (IBUS2)
/IBUS3: P1.C18 (IBUS3)
/IBUS4: P1.C19 (IBUS4)
/IBUS5: P1.C20 (IBUS5)
/IBUS6: P1.C21 (IBUS6)
/IBUS7: P1.C22 (IBUS7)
/IBUS8: P1.C23 (IBUS8)
/IBUS9: P1.C24 (IBUS9)
/IBUS10: P1.C25 (IBUS10)
/IBUS11: P1.C26 (IBUS11)
/IBUS12: P1.C27 (IBUS12)
/IBUS13: P1.C28 (IBUS13)
/IBUS14: P1.C29 (IBUS14)
/IBUS15: P1.C30 (IBUS15)
/IR0: P1.B23 (UB22)
/IR1: P1.B24 (UB23)
/IR2: P1.B25 (UB24)
/IR3: P1.B26 (UB25)
/IR4: P1.B27 (UB26)
/IR5: P1.B28 (UB27)
/IR6: P1.B29 (UB28)
/IR7: P1.B30 (UB29)
/POWEROK: D4.2 (A), J13.6, P1.A22 (UB21), R2.2
/POWERON: J13.7, J14.1
/RADDR0: P1.C4 (RADDR0)
/RADDR1: P1.C6 (RADDR1)
/RADDR2: P1.B6 (RADDR2)
/RADDR3: P1.B7 (RADDR3)
/RADDR4: P1.B8 (RADDR4)
/SPARE: C10.1, J13.4, TP1.1
/STANDBY: J13.5, R3.2
/T34: P1.C3 (T34), P2.A4 (T34)
/WADDR0: P1.B9 (WADDR0)
/WADDR1: P1.B10 (WADDR1)
/WADDR2: P1.B11 (WADDR2)
/WADDR3: P1.B12 (WADDR3)
/WADDR4: P1.B13 (WADDR4)
/~END: P1.C13 (~END)
/~ENDEXT: P1.C14 (~ENDEXT)
/~FPAEXT: P1.A14 (UB13)
/~FPCLK~⁄CLK: P1.A5 (UB4)
/~FPCTX: P1.A6 (UB5)
/~FPDRH: P1.A18 (UB17)
/~FPDRL: P1.A17 (UB16)
/~FPFLAGS: P1.A13 (UB12)
/~FPIRH: P1.A12 (UB11)
/~FPIRL: P1.A7 (UB6)
/~FPPCH: P1.A16 (UB15)
/~FPPCL: P1.A15 (UB14)
/~FPRAM~∕ROM: P1.A19 (UB18)
/~FPRESET: P1.A21 (UB20)
/~FPµA0: P1.A8 (UB7)
/~FPµC0: P1.A9 (UB8)
/~FPµC1: P1.A10 (UB9)
/~FPµC2: P1.A11 (UB10)
/~HALT: P2.B3 (~HALT)
/~IO: P2.B11 (~IO)
/~IODEV1XX: P2.A13 (~IODEV1XX)
/~IODEV2XX: P2.A9 (~IODEX2XX)
/~IODEV3XX: P2.A8 (~IODEV3XX)
/~IRQ: P2.B4 (~IRQ)
/~IRQ0: P2.C23 (~IRQ0)
/~IRQ1: P2.C24 (~IRQ1)
/~IRQ2: P2.C25 (~IRQ2)
/~IRQ3: P2.C26 (~IRQ3)
/~IRQ4: P2.C27 (~IRQ4)
/~IRQ5: P2.C28 (~IRQ5)
/~IRQ6: P2.C29 (~IRQ6)
/~IRQ7: P2.C30 (~IRQ7)
/~IRQS: P2.C14 (~IRQS)
/~MEM: P2.B10 (~MEM)
/~R: P2.C12 (~R)
/~RESET: P2.A3 (~RESET)
/~RSTHOLD: P2.C3 (~RSTHOLD)
/~SKIPEXT: P1.B22 (~SKIPEXT)
/~SYSDEV: P2.A12 (~SYSDEV)
/~W: P2.C13 (~W)
/~WAITING: P2.A14 (~WAITING)
/~WRITE-FL: P1.C11 (~WRITE-FL)
/~WS: P2.A6 (AB2)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, D1.1 (K), D2.1 (K), D3.1 (K), J13.1, J13.2, J13.3, J14.2, P1.A31 (GND), P1.A32 (GND), P1.B4 (GND), P1.B5 (GND), P1.B31 (GND), P1.B32 (GND), P1.C31 (GND), P1.C32 (GND), P2.A31 (GND), P2.A32 (GND), P2.B31 (GND), P2.B32 (GND), P2.C31 (GND), P2.C32 (GND), U1.3 (GND), U1.4 (GND), U2.3 (GND), U2.4 (GND), U3.3 (GND), U3.4 (GND), U4.3 (GND), U4.4 (GND), U5.3 (GND), U5.4 (GND), U6.3 (GND), U6.4 (GND); also elsewhere on the board
unnamed: D1.2 (A), R1.1
unnamed: D2.2 (A), R2.1
unnamed: D3.2 (A), R3.1

Notes on the sheet:
[RW]ADDR 01000 01001 01010 01011
Reg PC DR AC SP
The '193 counters used here treat these as clocks and increment/decrement on the signals' rising edge. This tends to be too late in the processor cycle. We can advance the action by using CLK3. Current microcode doesn't use it, but this also fixes a potential bug that would prohibit incrementing a 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
The Control Unit Board
This board contains a number of relatively simple units. The interconnections and feeback loops between these units make this a Turing Complete design, and an actual processor at that. Nearly every unit here except the clock generator feeds back into another one. The core of the design is the Micro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
Note: IDX Registration
IDX0 and IDX1 are not registered because they rely solely on the current value of the IR. IR is latched during CLK4, so at worst IDX will be valid at CLK1 + ~20ns.
Processor Bus
Local Bus
Peripheral Bus
A10
A11
A12
A13
A14
A17
A18
A19
A20
A21
A22
A23
A24
A25
A26
A27
A28
A29
A30
A31
A32
C32
C31
C30
C29
C28
C27
C26
C25
C24
