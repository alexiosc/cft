# Repository alexiosc/cft (continued)

## KiCad design kicad/cft/tic/tic.kicad_pcb

Board: 2 copper layers, 233.4 x 280.0 mm, 105 parts (0 on the bottom side), 175 nets.

Parts:
C1, C5, C6, C33, C34, C35, C36, C37, C38, C39, C41, C42, C43, C44, C45, C46, C47, C48, C49, C605, C611, C620, C621: 100nF; C_SMD_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3, C4: 47µF; CP_Radial_D6.3mm_P2.50mm
C601, C602, C604, C606, C607, C608, C609, C610, C612, C613, C614, C615, C616, C617, C618, C619: 1μF; CP_Radial_D6.3mm_P2.50mm
C603: 1nF 3kV; C_1206_3216Metric
C622, C623: 47pF; C_SMD_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C624: 4.7µF; CP_Radial_D6.3mm_P2.50mm
D1, D2, D11: CUS520; SOD-323
D601, D602: LED_ALT; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: USB_B_Micro; USB_Micro-B_Molex_47346-0001
J601, J602: DE9-Female-with-Shield; DSUB-9_Female_Horizontal_P2.77x2.84mm_EdgePinOffset4.94mm_H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
JP1, JP2: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
JP3, JP4, JP5: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP6: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm
P1, P2: CFT-2021-Processor-Bus; DIN41612_B_3x32_Horizontal
R17, R18, R19, R20, R21, R22: 4.7kΩ; R_SMD_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R601, R602: 27Ω; R_SMD_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R603, R604: 560Ω; R_SMD_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U1: 74HCT245; DIP-20_W7.62mm_Socket
U2, U6: 8254; DIP-24_W15.24mm_socket
U3, U7: 74LVC1G10; SOT-23-6_Handsoldering
U4, U8, U9, U17: USB6B1; SOIC-8
U5, U44: 74LVC1G08; SOT-23-5_HandSoldering
U9#2, U101: W5100; LQFP-80_10x10mm_P0.4mm
U32: 74HC574; DIP-20_W7.62mm_Socket
U33: M48T02-70PC1; eDIP-24_W15.24mm
U34, U35: 74HC541; SOIC-20W
U36, U39: 74HC139; SOIC-16
U37, U38: 74HC138; SOIC-16
U40: 74LVC1G11; SOT-23-6_Handsoldering
U41: 74HC74; SOIC-14
U42: 74LVC1G07; SOT-23-5_HandSoldering
U102: ESP-WROOM-02
U301: ATF16V8B; DIP-20_W7.62mm_Socket
U601, U603, U604, U605: MAX232; DIP-16_W7.62mm_Socket
U602: STC16C554; PLCC68
U606: FT231XS; SSOP-20_3.9x8.7mm_P0.635mm
X1: 32.768 kHz; Crystal_SMD_7050-4Pin_7.0x5.0mm
X601: 7.3728 MHz; Oscillator_DIP-8

Connections:
+5V: C1.1, C3.1, C4.1, C5.1, C6.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C47.1, C48.1, C49.1, C605.1, C611.1, P1.A1, P1.B1, P1.C1, P2.A1, P2.A2, P2.B1, P2.B2, P2.C1, P2.C2, R17.1, R18.1, R19.1, R20.1, R21.1, R22.1, U1.20, U2.24, U3.5, U4.1, U5.5, U6.24, U7.5, U8.1, U17.1, U32.20, U33.19, U33.22, U33.23, U33.24, U34.2, U34.3, U34.4, U34.5, U34.20, U35.2, U35.3, U35.4, U35.5, U35.20, U36.16, U37.16, U38.6, U38.16, U39.16, U40.5, U41.1, U41.13, U41.14, U42.5, U44.5, U601.16, U602.13, U602.30, U602.47, U602.54, U602.64, U603.16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
+12V: P2.A7, P2.B7, P2.C7
/AB0: P2.C4, U2.19, U6.19, U602.32
/AB1: P2.A5, U2.20, U6.20, U36.2, U36.14, U39.2, U39.14, U301.1, U602.33
/AB2: P2.A6, U38.1, U301.2, U602.34
/AB3: P2.C6, U38.2, U301.3, U602.20
/AB4: P2.C8, U37.6, U38.3, U301.4, U602.50
/AB5: P2.C9, U37.2, U301.5
/AB6: P2.C10, U37.1, U301.6
/AB7: P2.C11, U37.5, U301.7
/Bus Interface/~IRCCS: U36.3, U36.13, U38.11
/Bus Interface/~SEL: U40.4, U41.2
/CLK3: U41.3, U41.11
/DB0: P2.A15, U1.9, U32.9, U33.9, U602.66
/DB1: P2.A16, U1.8, U32.8, U33.10, U602.67
/DB2: P2.A17, U1.7, U32.7, U33.11, U602.68
/DB3: P2.A18, U1.6, U32.6, U33.13, U602.1
/DB4: P2.A19, U1.5, U32.5, U33.14, U602.2
/DB5: P2.A20, U1.4, U32.4, U33.15, U602.3
/DB6: P2.A21, U1.3, U32.3, U33.16, U602.4
/DB7: P2.A22, U1.2, U32.2, U33.17, U602.5
/Quad Serial Board/CTSC: U602.45, U606.2
/Quad Serial Board/D'+: C623.1, R601.1, U9.2
/Quad Serial Board/D'-: C622.1, R602.1, U9.3
/Quad Serial Board/D+: J1.3, U9.7
/Quad Serial Board/D-: J1.2, U9.6
/Quad Serial Board/DSRC: U602.43, U602.44, U606.1
/Quad Serial Board/DTRC: U602.46, U606.7, U606.8
/Quad Serial Board/RS-CTSA: J601.7, U601.8
/Quad Serial Board/RS-CTSB: J602.7, U604.8
/Quad Serial Board/RS-DCDA: J601.1, U603.8
/Quad Serial Board/RS-DCDB: J602.1, U605.8
/Quad Serial Board/RS-DSRA: J601.6, U603.13
/Quad Serial Board/RS-DSRB: J602.6, U605.13
/Quad Serial Board/RS-DTRA: J601.4, U603.14
/Quad Serial Board/RS-DTRB: J602.4, U605.14
/Quad Serial Board/RS-RIA: J601.9, U603.7
/Quad Serial Board/RS-RIB: J602.9, U605.7
/Quad Serial Board/RS-RTSA: J601.8, U601.7
/Quad Serial Board/RS-RTSB: J602.8, U604.7
/Quad Serial Board/RS-RXA: J601.3, U601.13
/Quad Serial Board/RS-RXB: J602.3, U604.13
/Quad Serial Board/RS-TXA: J601.2, U601.14
/Quad Serial Board/RS-TXB: J602.2, U604.14
/Quad Serial Board/RTSC: U602.48, U606.9
/Quad Serial Board/RX0: U601.12, U602.7
/Quad Serial Board/RX1: U602.29, U604.12
/Quad Serial Board/RXC: U602.41, U606.20
/Quad Serial Board/TX0: U601.11, U602.17
/Quad Serial Board/TX1: U602.19, U604.11
/Quad Serial Board/TXC: U602.51, U606.4
/Quad Serial Board/USBD+: R601.2, U606.11
/Quad Serial Board/USBD-: R602.2, U606.12
/Quad Serial Board/~CD0: U602.9, U603.9
/Quad Serial Board/~CD1: U602.27, U605.9
/Quad Serial Board/~CTS0: U601.9, U602.11
/Quad Serial Board/~CTS1: U602.25, U604.9
/Quad Serial Board/~DSR0: U602.10, U603.12
/Quad Serial Board/~DSR1: U602.26, U605.12
/Quad Serial Board/~DTR0: U602.12, U603.11
/Quad Serial Board/~DTR1: U602.24, U605.11
/Quad Serial Board/~RI0: U602.8, U603.10
/Quad Serial Board/~RI1: U602.28, U605.10
/Quad Serial Board/~RTS0: U601.10, U602.14
/Quad Serial Board/~RTS1: U602.22, U604.10
/Quad Serial Board/~RXLED: R604.1, U606.10
/Quad Serial Board/~TXLED: R603.1, U606.17
/Real Time Clock/DB8: P2.A23, U34.18, U35.18
/Real Time Clock/DB9: P2.A24, U34.17, U35.17
/Real Time Clock/DB10: P2.A25, U34.16, U35.16
/Real Time Clock/DB11: P2.A26, U34.15, U35.15
/Real Time Clock/DB12: P2.A27, U34.14, U35.14
/Real Time Clock/DB13: P2.A28, U34.13, U35.13
/Real Time Clock/DB14: P2.A29, U34.12, U35.12
/Real Time Clock/DB15: P2.A30, U34.11, U35.11
/Real Time Clock/RTCA0: U32.12, U33.8
/Real Time Clock/RTCA1: U32.13, U33.7
/Real Time Clock/RTCA2: U32.14, U33.6
/Real Time Clock/RTCA3: U32.15, U33.5
/Real Time Clock/RTCA4: U32.16, U33.4
/Real Time Clock/RTCA5: U32.17, U33.3
/Real Time Clock/RTCA6: U32.18, U33.2
/Real Time Clock/RTCA7: U32.19, U33.1
/Timers/G0-0: R17.2, U2.11, U4.2
/Timers/G0-1: R18.2, U2.14, U4.3
/Timers/G0-2: R19.2, U2.16, U8.2
/Timers/G1-0: R20.2, U6.11, U8.3
/Timers/G1-1: R21.2, U6.14, U17.3
/Timers/G1-2: R22.2, U6.16, U17.2
/Timers/OUT0-0: U2.10, U3.6
/Timers/OUT0-1: U2.13, U3.3
/Timers/OUT0-2: U2.17, U3.1
/Timers/OUT1-0: U6.10, U7.6
/Timers/OUT1-1: U6.13, U7.3
/Timers/OUT1-2: U6.17, U7.1
/Timers/TCLK: U2.9, U2.15, U2.18, U6.9, U6.15, U6.18, X1.3
/Timers/TD0: U1.11, U2.8, U6.8
/Timers/TD1: U1.12, U2.7, U6.7
/Timers/TD2: U1.13, U2.6, U6.6
/Timers/TD3: U1.14, U2.5, U6.5
/Timers/TD4: U1.15, U2.4, U6.4
/Timers/TD5: U1.16, U2.3, U6.3
/Timers/TD6: U1.17, U2.2, U6.2
/Timers/TD7: U1.18, U2.1, U6.1
/Timers/~CS: U1.19, U5.4
/~IRQ0i: JP1.2, JP2.2
/~IRQ1i: JP1.4, JP2.4
/~IRQ2i: JP1.6, JP2.6
/~R: P2.C12, U1.1, U2.22, U6.22, U35.19, U36.1, U301.9, U602.52
/~RESET: P2.A3, U41.4, U41.10
/~RSTHOLD: P2.C3, U602.37, U606.14
/~RTCAW: U32.11, U39.12
/~RTCCS: JP5.1, U33.18, U34.19, U38.7, U39.3, U39.13
/~RTCR: U33.20, U34.1, U39.5
/~RTCW: U33.21, U39.11
/~SYSDEV: U37.4, U38.4
/~T0CS: JP3.1, U2.21, U5.2, U35.6, U38.10, U44.2
/~T1CS: JP4.1, U5.1, U6.21, U35.7, U38.9, U44.1
/~W: P2.C13, U2.23, U6.23, U36.15, U39.15, U301.8, U602.18
/~WS: D11.2, P2.C5, U42.4
Earth: C603.1, J1.6, J601.0, J602.0
GND: C1.2, C3.2, C4.2, C5.2, C6.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C601.1, C602.1, C603.2, C604.1, C605.2, C608.1, C611.2, C612.1, C613.1, C616.1, C617.1, C620.2, C621.2, C622.2, C623.2, C624.2, J1.5, J601.5, J602.5, P1.A31, P1.A32, P1.B4, P1.B5, P1.B31, P1.B32, P1.C31, P1.C32, P2.A31, P2.A32, P2.B31, P2.B32, P2.C31, P2.C32, U1.10, U2.12, U3.2, U4.4, U5.3, U6.12, U7.2, U8.4, U9.4, U9.5, U17.4, U32.1, U32.10, U33.12, U34.6, U34.7, U34.8, U34.9, U34.10, U35.8, U35.9, U35.10, U36.8, U37.3, U37.8, U38.8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
unnamed: C601.2, U601.2
unnamed: C602.2, U601.6
unnamed: C604.2, U603.6
unnamed: C606.1, U601.1
unnamed: C606.2, U601.3
unnamed: C607.1, U601.4
unnamed: C607.2, U601.5
unnamed: C608.2, U603.2
unnamed: C609.1, U603.1
unnamed: C609.2, U603.3
unnamed: C610.1, U603.4
unnamed: C610.2, U603.5
unnamed: C612.2, U604.6
unnamed: C613.2, U604.2
unnamed: C614.1, U604.1
unnamed: C614.2, U604.3
unnamed: C615.1, U604.4
unnamed: C615.2, U604.5
unnamed: C616.2, U605.6
unnamed: C617.2, U605.2
unnamed: C618.1, U605.1
unnamed: C618.2, U605.3
unnamed: C619.1, U605.4
unnamed: C619.2, U605.5
unnamed: C620.1, U606.13
unnamed: C621.1, C624.1, D601.1, D602.1, U9.1, U606.3, U606.15
unnamed: D1.1, U3.4
unnamed: D1.2, JP1.1, JP1.3, JP1.5
unnamed: D2.1, U7.4
unnamed: D2.2, JP2.1, JP2.3, JP2.5
unnamed: D11.1, JP6.2, U42.2
unnamed: D601.2, R603.2
unnamed: D602.2, R604.2
unnamed: J1.1, U9.8
unnamed: JP3.2, U40.3
unnamed: JP4.2, U40.1
unnamed: JP5.2, U40.6
unnamed: JP6.1, U41.5, U41.12
unnamed: JP6.3, U41.9
unnamed: U9#2.7, U9#2.74
unnamed: U9#2.4, U9#2.10, U9#2.77
unnamed: U9#2.12, U9#2.18, U9#2.44
unnamed: U9#2.13, U9#2.14, U9#2.17, U9#2.32, U9#2.43, U9#2.68
unnamed: U9#2.15, U9#2.16, U9#2.33, U9#2.69
unnamed: U35.1, U44.4
unnamed: U37.15, U38.5
unnamed: U101.7, U101.74
unnamed: U101.4, U101.10, U101.77
unnamed: U101.12, U101.18, U101.44
unnamed: U101.13, U101.14, U101.17, U101.32, U101.43, U101.68
unnamed: U101.15, U101.16, U101.33, U101.69
unnamed: U102.9, U102.13, U102.18, U102.19
unnamed: U602.35, X601.5

## KiCad design kicad/cft/cft-backplane/cft-backplane-peripheral.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6: 47µF; CP_Radial_D6.3mm_P2.50mm
C7, C8, C9: 100µF; CP_Radial_D6.3mm_P2.50mm
C10: 100µF 16V; CP_Radial_D6.3mm_P2.50mm
C11, C12, C13, C14, C16: 100nF; C_SMD_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1, D2, D4: LED_ALT; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D3: 1N4148?; SOD-323
H25, H26, H27, H28, H29, H30: MountingHole_Pad; MountingHole_2.7mm_M2.5_ISO14580_Pad
J13: CUI TBP02R1-381-12BE; CUI-TBP02R1-381-12BE
J14: 2.54mm header; PinHeader_2x01_P2.54mm_Vertical
R1, R2, R3, R4: 1kΩ; R_SMD_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R5, R6, R7, R8, R9, R10, R11, R12: 100kΩ; R_SMD_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U1, U2, U3, U4, U6: SN74ACT1071; SOIC-14

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C11.1, C12.1, C13.1, C14.1, C16.1, D1.2 (A), J13.1, J13.2, J13.3, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, U1.10 (VCC), U1.11 (VCC), U2.10 (VCC), U2.11 (VCC), U3.10 (VCC), U3.11 (VCC), U4.10 (VCC), U4.11 (VCC), U6.10 (VCC), U6.11 (VCC); also elsewhere on the board
+12V: C10.1, J13.4, J13.5; also elsewhere on the board
/A3: D3.2 (A); also elsewhere on the board
/A5: U1.13 (D9); also elsewhere on the board
/A6: U1.12 (D8); also elsewhere on the board
/A8: R12.2; also elsewhere on the board
/A9: R11.2; also elsewhere on the board
/A12: R9.2; also elsewhere on the board
/A13: R10.2; also elsewhere on the board
/A15: U3.14 (D10); also elsewhere on the board
/A16: U3.12 (D8); also elsewhere on the board
/A17: U6.1 (D1); also elsewhere on the board
/A18: U6.5 (D3); also elsewhere on the board
/A19: U6.7 (D5); also elsewhere on the board
/A20: U6.9 (D7); also elsewhere on the board
/A21: U6.8 (D6); also elsewhere on the board
/A22: U2.14 (D10); also elsewhere on the board
/A23: U2.13 (D9); also elsewhere on the board
/A24: U2.1 (D1); also elsewhere on the board
/A25: U2.2 (D2); also elsewhere on the board
/A26: U2.5 (D3); also elsewhere on the board
/A27: U2.6 (D4); also elsewhere on the board
/A28: U2.7 (D5); also elsewhere on the board
/A29: U2.9 (D7); also elsewhere on the board
/A30: U2.8 (D6); also elsewhere on the board
/AB0: U1.14 (D10); also elsewhere on the board
/AB3: U1.1 (D1); also elsewhere on the board
/AB4: U1.5 (D3); also elsewhere on the board
/AB5: U1.6 (D4); also elsewhere on the board
/AB6: U1.7 (D5); also elsewhere on the board
/AB7: U1.8 (D6); also elsewhere on the board
/AB8: U3.1 (D1); also elsewhere on the board
/AB9: U3.13 (D9); also elsewhere on the board
/AB10: U6.2 (D2); also elsewhere on the board
/AB11: U6.6 (D4); also elsewhere on the board
/AB12: U6.12 (D8); also elsewhere on the board
/AB13: U3.8 (D6); also elsewhere on the board
/AB14: U4.1 (D1); also elsewhere on the board
/AB15: U4.2 (D2); also elsewhere on the board
/AB16: U4.5 (D3); also elsewhere on the board
/AB17: U4.14 (D10); also elsewhere on the board
/AB18: U4.13 (D9); also elsewhere on the board
/AB19: U4.12 (D8); also elsewhere on the board
/AB20: U4.9 (D7); also elsewhere on the board
/AB21: U4.8 (D6); also elsewhere on the board
/AB22: U4.6 (D4); also elsewhere on the board
/AB23: U4.7 (D5); also elsewhere on the board
/B10: R5.2; also elsewhere on the board
/B11: R6.2; also elsewhere on the board
/C12: R7.2; also elsewhere on the board
/C13: R8.2; also elsewhere on the board
/POWEROK: J13.7, R2.2, R3.2
/POWERON: J13.9, J14.1
/VSTB: J13.8, R4.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C16.2, D2.1 (K), D4.1 (K), H25.1, H26.1, H27.1, H28.1, H29.1, H30.1, J13.10, J13.11, J13.12, J14.2, R1.1, U1.3 (GND), U1.4 (GND), U2.3 (GND), U2.4 (GND), U3.3 (GND), U3.4 (GND), U4.3 (GND), U4.4 (GND), U6.3 (GND), U6.4 (GND); also elsewhere on the board
unnamed: D1.1 (K), R1.2
unnamed: D2.2 (A), R2.1
unnamed: D3.1 (K), R3.1
unnamed: D4.2 (A), R4.1

Notes on the sheet:
Processor Bus Backplane
This is a 12-slot backplane specifically for the processor bus. Since there are a lot of short, point-to-point signals travelling on the processor bus, this backplane has a number of unbussed pins, which need to be wired from slot to slot (thus making some slots specialised, like the backplane slot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
A10
A11
A12
A13
A14
A17
A18
A19
A20
A21
A22
A23
A24
A25
A26
A27
A28
A29
A30
A31
A32
C32
C31
C30
C29
C28
C27
C26
C25
C24
C23
C22
C21
C20
C19
C18
C17
C16
