File: kicad/cft/cft_microcode.sch (KiCad schematic (older format))
At the start: 18 parts, among them SW3101 SW_DIP_x03, U3002 74AHC1G08, U3101 74HC161, U3102 74LVC1G00, U3103 74AHC1G08, U3104 74AHC1G00, U3105 74HC85, U3106 SN74ACT1071

Commit message: Removed widebus buffer from microcode store µAddr High
Parts:
- renumbered C3101 to C1701, C3103 to C1702, C3102 to C1703, C3106 to C1904, C3104 to C?, C3105 to C?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
