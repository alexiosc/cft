# Repository alexiosc/cft

File README:

# The CFT Home-Brew 16-bit Mini-Computer

The CFT is a home-designed, home-built mini-computer made from
scratch.

I've designed and built the instruction set, data path, processor,
computer, software stack, cross-assembler, emulator, software
toolchain and even some of the tools needed to do all this. You can
call this a ‘fantasy mini’.

This project has been going since approximately 2001, in my Copious
Free Time.

## Audience

There isn't one, so I couldn't tell you what it's like. This project
has been online for since 2005 and it's been noticed by four or five
people. Not quite enough for statistics.

**This is a personal project, and the repository is made public as a
curiosity. Expect everything to be wrong, broken, or dangerous.**

## Why?

Because it's fun.

To see how it's done.

To recall Those Heady Times.

To prove to myself I can do this.

## What?

The CFT is a long-term project built in my Copious Free Time. (a term used, as
always, sarcastically, hence the name) It's a homebrew, self-designed,
self-built Sixties-style 16-bit mini computer built out of 74-family integrated
circuits. Check out the
[ChangeLog](https://github.com/alexiosc/cft/blob/master/Changelog) for the
current status.

There may possibly be more stuff to look at, at https://www.bedroomlan.org/cft.

The project consists of:

* The CFT processor.
* Peripherals and cards, some implementing extensions to the CFT instruction set.
* A front panel with blinkenlights.
* A case for the lot.
* Documentation for everything, including the website and this.
* A cross-toolchain for working on the computer from a PC.

### The CFT Processor

* A 4 MHz clock. (250ns processor cycle)
* 16-bit word length. No byte access.
* 24-bit memory address bus.
* 16-bit I/O bus shared with the address bus. (the lower 1,024 addresses are easier to use)
* All instructions are exactly one 16-bit word long.
* Some instructions follow the PDP-8 ‘microcoded’ format with bitfields cotrolling combinations of actions. Bitwise negation, two's complement negation and incrementation are the same instruction with slightly different options.
* A relatively simple instruction set inspired by the PDP-8. This has moved on
  to something slightly more reminiscent of a modern processor.
* Microcoded design.
* Accumulator based architecture.
* Four user-accessible 16-bit registers with increment and decrement. Only the
  Accumulator (AC) is general purpose.
* PDP-8 style magic addresses working like auto-increment or auto-decrement
  index registers, or stack pointers.

### Peripherals

I originally sat down with Eagle CAD and went *crazy* with it. I had 50 sheets
of schematics for boards, all with a three-letter designator:

* MEM: A memory board with 512 KWords of RAM and 512 KWords of ROM.
* TTY: A quadruple serial board including both DCE and DTE
  connections, and a TTL one for an FTDI USB adaptor.
* INT: 8-interrupt controller board.
* IDE: Twin IDE bus interface for up to four drives.
* RTC: A real-time card with some NVRAM and three or six programmable timers.
* ETH: An offloaded Ethernet interface using the WIZ812 chip.
* KBD: A PS/2 Keyboard interface in pure discrete logic.
* PSG: A sound board with one or two AY-3-8910 chips and a SpeakJet® speech synthesiser.
* PFP: A Programmer's Front Panel capable of debugging microcode as well as full machine code.
* DEB: A DEBugging card to help diagnose problems with the hardware
  using a remote controller. (this was basically a simple, slow, specialised logic analyser)
* FDC: A Floppy Drive Controller for up to four drives, including 8-inch 50-pin ones.
* GIO: General Purpose I/O board including some digital I/O, two
  Atari-style digital joystick ports, a unidirectional parallel
  printer port, four user-controllable LEDs on the front panel (the
  PFP already had 16) and (on a whim) a cassette tape interface.
* MBU: processor extension to allow 21-bit memory addressing (up to 2 MWords).
* µCB: processor extension to allow multiple versions of microcode to co-exist. (I had spare space in the Microcode ROMs)
* VDU: a graphics card that does text at 80×25 and 40×25, and graphics
  at combinations of 160, 320, 640 columns and 100, 200, 400 rows with
  64 colours.

The currently planned peripherals are much more modest in scope, but
they also morphed quite a bit. The processor can now do 24-bit
addressing natively, the current microcode uses all of the available
ROM space and a bunch of cards have joined forces. The current state
of affairs looks like this:

* MEM: (tentative design) 512 kWords or 1 MWord of RAM, 512 KWords of
  ROM. Multiple cards can be installed. If density allows, there'll be
  more chip sockets for RAM.
* INT: 8 interrupt controller board.
* DFP: a big card containing both a remote debugging system and front panel drivers.
* TTY: serial port card, possibly colocated with…
* IDE: one or two IDE sockets for two or four IDE drives. (or CF
  cards, but I like the possibility of having some clunky old drive)
* SND: MIDI sound output. Possibly collocated with…
* VDU: a graphics card that does text at 80×30 and 40×30, and graphics
  at combinations of 160, 320, 640 columns and 120, 240, 480 rows
  using 64 colours. The new VDU card fits inside a CPLD and also
  includes a PS/2 interface.
* RTC: Real-time clock, timers.

I've built the MEM and DFP boards to pre-2019 specs and the computer was
working on them.

The 2019 redesign goes for proper PCBs for everything, so things are
taking a little extra time.

### Front Panel

I was really proud of the front panel before the 2019 redesign, it
worked great and showed the computer's entire status. There's support
for up to 160 lights, 31 switches and two keylocks for that PDP-8
feel.

The downside was the wiring: there were no fewer than *five* 50-wire
ribbon cables going to this crazy bastard.

The 2019 redesign keeps the layout, but can no longer display as much
of the computer's status on the front panel. I'm working on it. On the
upside, it now serialises data transmission and only a single 40-pin
cable is needed.

To cut costs, the original front panel was made out of eight modules,
each with up to 20 LEDs. The new front panel is made out of four
modules, each with up to 40 LEDs. Each module daisy-chains to the
next.

Switches are mounted on a separate plate and wired to a break-out
board, or the closest front panel modules on the 2019 version.

### The Case

Two words: wood paneling. Well, and a black acrylic front piece. The
rest will depend on how big the card cage gets, but I'll scratch make
the case out of sheet aluminium and wood.

### Documentation

There's just too much of it. The documentation was initially in LaTeX
and got up to 500 pages before I gave that up and started converting
it to HTML.

The 2019 redesign will need a redo of most of this, sadly, but the
current documents for hardware that's currently around are available
at https://www.bedroomlan.org/hardware/cft/book/.

### Software and Hardware Tools

I had to make my own tools for some of this, and *wanted* to make my
own for some other parts.

Hardware tools include
[Flashprog](https://www.bedroomlan.org/hardware/flashprog/), a
zero-parts flash programmer with a modern serial interface. The
interface formed the basis of the DEB and DFP cards' remote debugging
interface and I'm quite happy with it.

Software tools include:

* The [Microcode
  Assembler](https://www.bedroomlan.org/projects/mcasm/), also
  available on Github as https://github.com/alexiosc/mcasm.
* The CFT Assembler, written purely in Python and roughly based on
  PDP-8 Assemblers, but with some modern extras like namespaces and
  simple macros.
* Too many emulators to speak of!
    ** A basic microcode-level emulator in Python to verify the original
	design. This one is dead and buried, but still in the repository.
	** A Verilog emulator used to verify the hardware.
	** A C emulator that's fast enough to run software on.
	** A [Javascript microcode-level
    emulator](https://www.bedroomlan.org/hardware/cft/microcode-emulator/)
    that runs on the web. It's very slow, but it shows how the front
    panel works.
	** A newer JS-based emulator meant to me much faster. Still
    largely in the works, because I prefer the C-based emulator for
    testing.
* A testing framework that can run test suites on any emulator we can
  use.
* A basic Operating System for the CFT.
* A self-documenting Forth interpreter written in Assembly and Forth.

## EAGLE design eagle/video-max5-revG-eagle7.brd

Notes on the sheet:
TODO:
* Check Signals
* Check Decoupling Capacitors
* Clean Up Layout
* Write & Verify Verilog Model
* Check Packages & IC Families
* Bill of Materials
* DRC
CFT
16-bit Mini-Computer
Video Display Unit (VDU) Board
This is a work in progress.
Sheet status is indicated here IN RED.
D: Draft
U: Untested
T: Initial Testing
Sheets being worked on are indicated by the 'TODO' frame
VCC is +5V unless otherwise indicated.
Notes
All decoupling capacitors are ceramic, 100nF.
All ICs are through-hole DIP packages.
Circuits known to be incorrect
are marked like this.
Circuits in need of improvement
All pull-ups and pull-downs are 4.7 kOhm.
Obsolete sections or circuits
This input signal is open drain.
This input signal may be at TTL logic levels.
This input may be at High Impedance.
This input (local to this board) may be at High Impedance.

Parts:
C1, C15, C16, C19: 47uF; E2-5
C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C17: 0.1uF; C0805K
C18: 47uF; E3,5-8
C20: 10uF; E2-5
C21: 22uF; E2-5
C34, C35: 1uF; C0805K
CON1: JTAG-ALTERA; SHROUDED-HEADER-2X5-2.5MM
IC1: 5M1270ZT144; TQFP144
IC2: AS7C34098A; SOJ44-4
IC3: AP1117D18; TO252
LED1: LED-5MM-GREEN; CHIPLED_0805
R1: 330R; R0805
RN1: 4.7k; CTS742C083
TP1: WIREPAD1,6/0,9; 1,6/0,9

Connections:
!IODEV1XX-3V3: IC1.68 (IO68); also elsewhere on the board
!PR: IC1.3 (IO3), IC2.41 (!OE)
!PW: IC1.32 (IO32), IC2.17 (!WE)
!R-3V3: IC1.75 (IO75); also elsewhere on the board
!RESET-3V3: IC1.60 (IO60/OE); also elsewhere on the board
!T34-3V3: IC1.63 (IO63)
!W-3V3: IC1.74 (IO74); also elsewhere on the board
+3V3: C3.2, C4.1, C6.2, C7.1, C9.2, C10.1, C12.2, C13.1, C14.1, C15.+, C16.+, C17.1, C18.+, C19.+, C34.1, C35.1, CON1.4 (VCCTRGT), IC1.9 (VCCIO1-1), IC1.21 (IO21), IC1.25 (VCCIO1-2), IC1.46 (VCCIO1-3), IC1.52 (IO52), IC1.53 (IO53), IC1.55 (IO55), IC1.57 (IO57), IC1.58 (IO58), IC1.64 (VCCIO1-4), IC1.73 (IO73), IC1.82 (VCCIO2-1), IC1.100 (VCCIO2-2), IC1.116 (VCCIO2-3), IC1.118 (IO118), IC1.119 (IO119), IC1.121 (IO121), IC1.123 (IO123), IC1.124 (IO124), IC1.125 (IO125), IC1.136 (VCCIO2-4), IC2.11 (VCC), IC2.33 (VCC), RN1.5, RN1.6, RN1.7, RN1.8; also elsewhere on the board
AB0-3V3: IC1.97 (IO97); also elsewhere on the board
AB1-3V3: IC1.95 (IO95); also elsewhere on the board
AB2-3V3: IC1.93 (IO93); also elsewhere on the board
AB3-3V3: IC1.88 (IO88); also elsewhere on the board
AB4-3V3: IC1.85 (IO85); also elsewhere on the board
AB5-3V3: IC1.81 (IO81); also elsewhere on the board
AB6-3V3: IC1.79 (IO79); also elsewhere on the board
AB7-3V3: IC1.77 (IO77); also elsewhere on the board
B0: IC1.114 (IO114); also elsewhere on the board
B0-IN: IC1.107 (IO107); also elsewhere on the board
B1: IC1.117 (IO117); also elsewhere on the board
B1-IN: IC1.108 (IO108); also elsewhere on the board
CG/!P!: IC1.141 (IO141), IC2.44 (A17)
CLK: IC1.18 (IO18/CLK0); also elsewhere on the board
DB0-3V3: IC1.98 (IO98); also elsewhere on the board
DB1-3V3: IC1.96 (IO96); also elsewhere on the board
DB2-3V3: IC1.94 (IO94); also elsewhere on the board
DB3-3V3: IC1.91 (IO91/CLK3); also elsewhere on the board
DB4-3V3: IC1.86 (IO86); also elsewhere on the board
DB5-3V3: IC1.84 (IO84); also elsewhere on the board
DB6-3V3: IC1.80 (IO80); also elsewhere on the board
DB7-3V3: IC1.78 (IO78); also elsewhere on the board
DB8-3V3: IC1.72 (IO72); also elsewhere on the board
DB9-3V3: IC1.71 (IO71); also elsewhere on the board
DB10-3V3: IC1.70 (IO70); also elsewhere on the board
DB11-3V3: IC1.69 (IO69); also elsewhere on the board
DB12-3V3: IC1.67 (IO67); also elsewhere on the board
DB13-3V3: IC1.66 (IO66); also elsewhere on the board
DB14-3V3: IC1.62 (IO62); also elsewhere on the board
DB15-3V3: IC1.61 (IO61/CLRN); also elsewhere on the board
G0: IC1.112 (IO112); also elsewhere on the board
G0-IN: IC1.105 (IO105); also elsewhere on the board
G1: IC1.113 (IO113); also elsewhere on the board
G1-IN: IC1.106 (IO106); also elsewhere on the board
GND: C1.-, C2.1, C3.1, C4.2, C5.1, C6.1, C7.2, C8.1, C9.1, C10.2, C11.1, C12.1, C13.2, C14.2, C15.-, C16.-, C17.2, C18.-, C19.-, C20.-, C21.-, C34.2, C35.2, CON1.2 (GND1), CON1.10 (GND2), IC1.8 (GND0), IC1.10 (GND1), IC1.17 (GND2), IC1.26 (GND3), IC1.47 (GND4), IC1.54 (GND5), IC1.65 (GND6), IC1.83 (GND7), IC1.92 (GND8), IC1.99 (GND9), IC1.115 (GND10), IC1.128 (GND11), IC1.135 (GND12), IC1.137 (GND13), IC2.6 (!CE), IC2.12 (GND), IC2.34 (GND), IC2.39 (!LB), IC2.40 (!UB), IC3.1 (GND), LED1.C; also elsewhere on the board
HS: IC1.122 (IO122); also elsewhere on the board
HS-IN: IC1.102 (IO102); also elsewhere on the board
INT: IC1.76 (IO76); also elsewhere on the board
KBCLK: IC1.127 (IO127); also elsewhere on the board
KBDAT: IC1.129 (IO129); also elsewhere on the board
MSCLK: IC1.134 (IO134); also elsewhere on the board
MSDAT: IC1.130 (IO130); also elsewhere on the board
unnamed: LED1.A, R1.2
PA0: IC1.142 (IO142), IC2.1 (A0)
PA1: IC1.144 (IO144), IC2.2 (A1)
PA2: IC1.2 (IO2), IC2.3 (A2)
PA3: IC1.4 (IO4), IC2.4 (A3)
PA4: IC1.5 (IO5), IC2.5 (A4)
PA5: IC1.38 (IO38), IC2.18 (A5)
PA6: IC1.40 (IO40), IC2.19 (A6)
PA7: IC1.42 (IO42), IC2.20 (A7)
PA8: IC1.44 (IO44), IC2.21 (A8)
PA9: IC1.48 (IO48), IC2.22 (A9)
PA10: IC1.45 (IO45), IC2.23 (A10)
PA11: IC1.43 (IO43), IC2.24 (A11)
PA12: IC1.41 (IO41), IC2.25 (A12)
PA13: IC1.39 (IO39), IC2.26 (A13)
PA14: IC1.37 (IO37), IC2.27 (A14)
PA15: IC1.1 (IO1), IC2.42 (A15)
PB/!PC!: IC1.143 (IO143), IC2.43 (A16)
PCLK: IC1.20 (IO20/CLK1); also elsewhere on the board
PD0: IC1.6 (IO6), IC2.7 (D0)
PD1: IC1.11 (IO11), IC2.8 (D1)
PD2: IC1.13 (IO13), IC2.9 (D2)
PD3: IC1.15 (IO15), IC2.10 (D3)
PD4: IC1.22 (IO22), IC2.13 (D4)
PD5: IC1.27 (IO27), IC2.14 (D5)
PD6: IC1.29 (IO29), IC2.15 (D6)
PD7: IC1.31 (IO31), IC2.16 (D7)
PD8: IC1.30 (IO30), IC2.29 (D8)
PD9: IC1.28 (IO28), IC2.30 (D9)
PD10: IC1.24 (IO24), IC2.31 (D10)
PD11: IC1.23 (IO23), IC2.32 (D11)
PD12: IC1.16 (IO16), IC2.35 (D12)
PD13: IC1.14 (IO14), IC2.36 (D13)
PD14: IC1.12 (IO12), IC2.37 (D14)
PD15: IC1.7 (IO7), IC2.38 (D15)
PIXCLK: IC1.109 (IO109); also elsewhere on the board
PIXCLK-IN: IC1.89 (IO89/CLK2); also elsewhere on the board
R0: IC1.110 (IO110); also elsewhere on the board
R0-IN: IC1.103 (IO103); also elsewhere on the board
R1: IC1.111 (IO111); also elsewhere on the board
R1-IN: IC1.104 (IO104); also elsewhere on the board
SCL: IC1.50 (IO50); also elsewhere on the board
SDA: IC1.51 (IO51); also elsewhere on the board
SKBRX: IC1.133 (IO133); also elsewhere on the board
SKBTX: IC1.132 (IO132); also elsewhere on the board
SMSRX: IC1.131 (IO131); also elsewhere on the board
STATUS: IC1.59 (IO59), R1.1
TCK: CON1.1 (TCK), IC1.35 (TCK), RN1.2
TDI: CON1.9 (TDI), IC1.34 (TDI), RN1.1
TDO: CON1.3 (TDO), IC1.36 (TDO), RN1.3
TMS: CON1.5 (TMS), IC1.33 (TMS), RN1.4
VCC: C20.+, IC3.2 (VIN); also elsewhere on the board
VCCINT: C1.+, C2.2, C5.2, C8.2, C11.2, C21.+, IC1.19 (VCCINT1), IC1.56 (VCCINT2), IC1.90 (VCCINT3), IC1.126 (VCCINT4), IC3.3 (VOUT), TP1.1
VS: IC1.120 (IO120); also elsewhere on the board
VS-IN: IC1.101 (IO101); also elsewhere on the board
WS: IC1.87 (IO87); also elsewhere on the board

Notes on the sheet:
Alternative 5M1270ZT144C5N
CPLD Power Supply
CPLD Depoupling
CPLD Power & JTAG
Video Memory
CPLD, Banks 1 & 2
CPLD, Banks 3 & 4

Parts:
C22, C23, C24, C25, C26, C27: 0.1uF; C0805K
C28: 47uF; E2-5
CON2: 2534-; PAK100/2500-34
CON3: 2534-5; PAK100/2500-5-34
IC4: TPD7S019-15DBQR; SSOP16
R2, R3: 4k7; R0805
R4, R5, R6, R7, R8, R9, R10, R11, R12: 412R; R0805

Connections:
+3V3: C23.1, IC4.7 (VCC-DDC); also elsewhere on the board
B0: CON3.17, R8.1; also elsewhere on the board
B0-IN: CON2.17; also elsewhere on the board
B1: CON3.15, R9.1; also elsewhere on the board
B1-IN: CON2.15; also elsewhere on the board
BLUE: CON3.5, IC4.3 (VIDEO1), R8.2, R12.2
G0: CON3.21, R6.1; also elsewhere on the board
G0-IN: CON2.21; also elsewhere on the board
G1: CON3.19, R7.1; also elsewhere on the board
G1-IN: CON2.19; also elsewhere on the board
GND: C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.-, CON2.16, CON2.18, CON2.20, CON2.22, CON2.24, CON2.26, CON2.28, CON2.30, CON2.31, CON2.32, CON2.34, CON3.2, CON3.4, CON3.6, CON3.8, CON3.10, CON3.16, CON3.18, CON3.20, CON3.22, CON3.24, CON3.26, CON3.28, CON3.30, CON3.31, CON3.32, CON3.34, IC4.6 (GND), IC4.10 (DDC-IN1), IC4.11 (DDC-IN2), R2.1, R3.1; also elsewhere on the board
GREEN: CON3.3, IC4.4 (VIDEO2), R6.2, R11.2
HS: IC4.13 (SYNC-IN1), R3.2; also elsewhere on the board
HS-IN: CON2.27; also elsewhere on the board
HS-TTL: CON3.9, IC4.14 (SYNC-OUT1)
unnamed: R5.2, R10.1
unnamed: R7.2, R11.1
unnamed: R9.2, R12.1
unnamed: C22.1, C24.1, IC4.8 (BYPASS)
PIXCLK: CON3.33; also elsewhere on the board
PIXCLK-IN: CON2.33; also elsewhere on the board
R0: CON3.25, R4.1; also elsewhere on the board
R0-IN: CON2.25; also elsewhere on the board
R1: CON3.23, R5.1; also elsewhere on the board
R1-IN: CON2.23; also elsewhere on the board
RED: CON3.1, IC4.5 (VIDEO3), R4.2, R10.2
VCC: C25.1, C26.1, C27.1, C28.+, IC4.1 (VCC-SYNC), IC4.2 (VCC-VIDEO); also elsewhere on the board
VS: IC4.15 (SYNC-IN2), R2.2; also elsewhere on the board
VS-IN: CON2.29; also elsewhere on the board
VS-TTL: CON3.7, IC4.16 (SYNC-OUT2)

Notes on the sheet:
Use 1% tolerance
Use 412R resistors (e.g. Farnell 2138893), or 820R + 430R resistors.
If 820R resistors are used, the second in-series resistor above should be 0R
or manually bridged.
Resistor DAC
ESD Protection & Level Translation
Analogue ground bypass
Video Output (to monitor or extender)
Video In

Parts:
C29, C30, C31, C32, C33, C42, C43, C45: 0.1uF; C0805K
C36: 22uF; E2-5
C44: 1uF; C0805K
CON8: MA05-2
IC5, IC6, IC7: TXB0108PWR; TSSOP20
IC8: TXB0104PWR; TSSOP14
IC9, IC11: LSF0204PW; TSSOP14
IC10: DS1085L; SO08
JP1: MA04-2
Q1, Q2: BSS138; SOT23
R13, R14, R15, R16: 4k7; R0805
RN2, RN3: 4.7k; CTS742C083
TP2, TP3, TP4: WIREPAD1,6/0,9; 1,6/0,9
U1, U2: BZA856AVL; SC70-5
XTAL1: 64.000; CRYSTAL-SMD-5X3.2MM

Connections:
!IODEV1XX: IC7.17 (B3); also elsewhere on the board
!IODEV1XX-3V3: IC7.4 (A3); also elsewhere on the board
!IRQ: JP1.6; also elsewhere on the board
!IRQ2: JP1.8; also elsewhere on the board
!IRQ3: JP1.2; also elsewhere on the board
!IRQ4: JP1.4; also elsewhere on the board
!R: IC8.13 (B1); also elsewhere on the board
!R-3V3: IC8.2 (A1); also elsewhere on the board
!RESET: IC7.12 (B8); also elsewhere on the board
!RESET-3V3: IC7.9 (A8); also elsewhere on the board
!W: IC8.12 (B2); also elsewhere on the board
!W-3V3: IC8.3 (A2); also elsewhere on the board
!WS: Q2.3 (D); also elsewhere on the board
+3V3: C33.1, C42.2, C44.1, IC5.2 (VA), IC5.10 (OE), IC6.2 (VA), IC6.10 (OE), IC7.2 (VA), IC7.10 (OE), IC8.1 (VA), IC8.8 (OE), IC9.1 (VA), IC9.8 (OE), IC10.3 (3V3), IC11.1 (VA), IC11.5 (A4), IC11.8 (OE), R13.2, R14.2, R15.2, R16.2, RN2.5, RN2.6, RN2.7, RN2.8, TP2.1, XTAL1.1 (TS), XTAL1.4 (VCC); also elsewhere on the board
AB0: IC5.18 (B2); also elsewhere on the board
AB0-3V3: IC5.3 (A2); also elsewhere on the board
AB1: IC5.16 (B4); also elsewhere on the board
AB1-3V3: IC5.5 (A4); also elsewhere on the board
AB2: IC5.14 (B6); also elsewhere on the board
AB2-3V3: IC5.7 (A6); also elsewhere on the board
AB3: IC5.12 (B8); also elsewhere on the board
AB3-3V3: IC5.9 (A8); also elsewhere on the board
AB4: IC6.18 (B2); also elsewhere on the board
AB4-3V3: IC6.3 (A2); also elsewhere on the board
AB5: IC6.16 (B4); also elsewhere on the board
AB5-3V3: IC6.5 (A4); also elsewhere on the board
AB6: IC6.14 (B6); also elsewhere on the board
AB6-3V3: IC6.7 (A6); also elsewhere on the board
AB7: IC6.12 (B8); also elsewhere on the board
AB7-3V3: IC6.9 (A8); also elsewhere on the board
CLK: XTAL1.3 (OUT); also elsewhere on the board
DB0: IC5.20 (B1); also elsewhere on the board
DB0-3V3: IC5.1 (A1); also elsewhere on the board
DB1: IC5.17 (B3); also elsewhere on the board
DB1-3V3: IC5.4 (A3); also elsewhere on the board
DB2: IC5.15 (B5); also elsewhere on the board
DB2-3V3: IC5.6 (A5); also elsewhere on the board
DB3: IC5.13 (B7); also elsewhere on the board
DB3-3V3: IC5.8 (A7); also elsewhere on the board
DB4: IC6.20 (B1); also elsewhere on the board
DB4-3V3: IC6.1 (A1); also elsewhere on the board
DB5: IC6.17 (B3); also elsewhere on the board
DB5-3V3: IC6.4 (A3); also elsewhere on the board
DB6: IC6.15 (B5); also elsewhere on the board
DB6-3V3: IC6.6 (A5); also elsewhere on the board
DB7: IC6.13 (B7); also elsewhere on the board
DB7-3V3: IC6.8 (A7); also elsewhere on the board
DB8: IC8.11 (B3); also elsewhere on the board
DB8-3V3: IC8.4 (A3); also elsewhere on the board
DB9: IC8.10 (B4); also elsewhere on the board
DB9-3V3: IC8.5 (A4); also elsewhere on the board
DB10: IC7.20 (B1); also elsewhere on the board
DB10-3V3: IC7.1 (A1); also elsewhere on the board
DB11: IC7.18 (B2); also elsewhere on the board
DB11-3V3: IC7.3 (A2); also elsewhere on the board
DB12: IC7.16 (B4); also elsewhere on the board
DB12-3V3: IC7.5 (A4); also elsewhere on the board
DB13: IC7.15 (B5); also elsewhere on the board
DB13-3V3: IC7.6 (A5); also elsewhere on the board
DB14: IC7.14 (B6); also elsewhere on the board
DB14-3V3: IC7.7 (A6); also elsewhere on the board
DB15: IC7.13 (B7); also elsewhere on the board
DB15-3V3: IC7.8 (A7); also elsewhere on the board
GND: C29.2, C30.2, C31.2, C32.2, C33.2, C36.-, C42.1, C43.2, C44.2, C45.2, CON8.9, IC5.11 (GND), IC6.11 (GND), IC7.11 (GND), IC8.7 (GND), IC9.7 (GND), IC10.4 (GND), IC10.5 (CTRL0), IC10.6 (CTRL1), IC11.7 (GND), Q1.2 (S), Q2.2 (S), U1.2 (G), U2.2 (G), XTAL1.2 (GND); also elsewhere on the board
INT: Q1.1 (G), R13.1, TP4.1; also elsewhere on the board
KBCLK: IC9.2 (A1), RN2.4; also elsewhere on the board
KBCLK-5V: CON8.1, IC9.13 (B1), RN3.1, U1.4 (3)
KBDAT: IC9.3 (A2), RN2.3; also elsewhere on the board
KBDAT-5V: CON8.2, IC9.12 (B2), RN3.2, U1.3 (2)
MSCLK: IC9.5 (A4), RN2.1; also elsewhere on the board
MSCLK-5V: CON8.4, IC9.10 (B4), RN3.4, U1.5 (4)
MSDAT: IC9.4 (A3), RN2.2; also elsewhere on the board
MSDAT-5V: CON8.3, IC9.11 (B3), RN3.3, U1.1
unnamed: JP1.1, JP1.3, JP1.5, JP1.7, Q1.3 (D)
PCLK: IC10.1 (CLK1); also elsewhere on the board
SCL: IC10.8 (SCL), R16.1; also elsewhere on the board
SDA: IC10.7 (SDA), R15.1; also elsewhere on the board
SKBRX: IC11.2 (A1); also elsewhere on the board
SKBRX-5V: CON8.5, IC11.13 (B1), U2.5 (4)
SKBTX: IC11.3 (A2); also elsewhere on the board
SKBTX-5V: CON8.7, IC11.12 (B2), U2.4 (3)
SMSRX: IC11.4 (A3); also elsewhere on the board
SMSRX-5V: CON8.10, IC11.11 (B3), U2.3 (2)
SMSTX-5V: CON8.6
VCC: C29.1, C30.1, C31.1, C32.1, C36.+, C43.1, C45.1, CON8.8, IC5.19 (VB), IC6.19 (VB), IC7.19 (VB), IC8.14 (VB), IC9.14 (VB), IC11.14 (VB), RN3.5, RN3.6, RN3.7, RN3.8; also elsewhere on the board
WS: Q2.1 (G), R14.1, TP3.1; also elsewhere on the board

Notes on the sheet:
CFT Bus Level Translation
Interrupt Selection (Open Drain)
Keyboard Level Translation and Input
Sun & PS/2 Keyboard/Mouse Connector
T=15.625 ns
MHz
Programmable Clock Generator (optional)
64 MHz Pixel Clock
Wait State Generation (Open Drain)
Rear Panel

Notices in the files:
eagle/video-max5-revG-eagle7.brd:
(c) 2012-2016 AlexiosC
(c) 2012-2013 AlexiosC
