# Repository alexiosc/cft (continued)

## EAGLE design eagle/video-max5-revG-eagle7.brd (continued)

Parts:
$4_37_$1: SIGNATURESILK; SIGNATURE
$4_39_$, $4_39_$1: OSHW-LOGOL; OSHW-LOGO-L
$4_40_$: QRCODE-CFT; CFT-QRCODE
C37, C38, C39, C40, C41: 1uF; E2,5-5
EXP: VG96-3K; VG96K
U3, U4, U5, U6: HOLE; STANDOFF_28_60

Connections:
!ENDEXT: EXP.B7 (7)
!HALT: EXP.A19 (19)
!IO: EXP.C14 (14)
!IODEV1XX: EXP.B24 (24); also elsewhere on the board
!IODEV2XX: EXP.B25 (25)
!IODEV3XX: EXP.B26 (26)
!IRQ: EXP.C29 (29); also elsewhere on the board
!IRQ0: EXP.C18 (18)
!IRQ1: EXP.C19 (19)
!IRQ2: EXP.C20 (20); also elsewhere on the board
!IRQ3: EXP.A13 (13); also elsewhere on the board
!IRQ4: EXP.A14 (14); also elsewhere on the board
!IRQ5: EXP.A15 (15)
!IRQ6: EXP.A16 (16)
!IRQ7: EXP.A18 (18)
!IRQS: EXP.A30 (30)
!MEM: EXP.C13 (13)
!R: EXP.C15 (15); also elsewhere on the board
!RESET: EXP.C30 (30); also elsewhere on the board
!RSTHOLD: EXP.B22 (22)
!SKIPEXT: EXP.B6 (6)
!SYSDEV: EXP.A28 (28)
!T34: EXP.B27 (27)
!W: EXP.C16 (16); also elsewhere on the board
!WS: EXP.B8 (8); also elsewhere on the board
![R1]: EXP.B9 (9)
![R6]: EXP.B10 (10)
![R7]: EXP.B11 (11)
![W1]: EXP.B12 (12)
*TPA: EXP.A17 (17)
*TPC: EXP.C17 (17)
+3V3: C37.+, C38.+, C39.+, EXP.A4 (4), EXP.B4 (4), EXP.C4 (4); also elsewhere on the board
+12V: EXP.A31 (31), EXP.B31 (31), EXP.C31 (31)
AB0: EXP.A5 (5); also elsewhere on the board
AB1: EXP.A6 (6); also elsewhere on the board
AB2: EXP.A7 (7); also elsewhere on the board
AB3: EXP.A8 (8); also elsewhere on the board
AB4: EXP.A9 (9); also elsewhere on the board
AB5: EXP.A10 (10); also elsewhere on the board
AB6: EXP.A11 (11); also elsewhere on the board
AB7: EXP.A12 (12); also elsewhere on the board
AB8: EXP.A20 (20)
AB9: EXP.A21 (21)
AB10: EXP.A22 (22)
AB11: EXP.A23 (23)
AB12: EXP.A24 (24)
AB13: EXP.A25 (25)
AB14: EXP.A26 (26)
AB15: EXP.A27 (27)
AEXT0: EXP.B13 (13)
AEXT1: EXP.B14 (14)
AEXT2: EXP.B15 (15)
AEXT3: EXP.B16 (16)
AEXT4: EXP.B17 (17)
AEXT5: EXP.B18 (18)
AEXT6: EXP.B19 (19)
AEXT7: EXP.B20 (20)
CLK1: EXP.A29 (29)
CLK2: EXP.B29 (29)
CLK3: EXP.B30 (30)
CLK4: EXP.B28 (28)
DB0: EXP.C5 (5); also elsewhere on the board
DB1: EXP.C6 (6); also elsewhere on the board
DB2: EXP.C7 (7); also elsewhere on the board
DB3: EXP.C8 (8); also elsewhere on the board
DB4: EXP.C9 (9); also elsewhere on the board
DB5: EXP.C10 (10); also elsewhere on the board
DB6: EXP.C11 (11); also elsewhere on the board
DB7: EXP.C12 (12); also elsewhere on the board
DB8: EXP.C21 (21); also elsewhere on the board
DB9: EXP.C22 (22); also elsewhere on the board
DB10: EXP.C23 (23); also elsewhere on the board
DB11: EXP.C24 (24); also elsewhere on the board
DB12: EXP.C25 (25); also elsewhere on the board
DB13: EXP.C26 (26); also elsewhere on the board
DB14: EXP.C27 (27); also elsewhere on the board
DB15: EXP.C28 (28); also elsewhere on the board
GND: C37.-, C38.-, C39.-, C40.-, C41.-, EXP.A1 (1), EXP.A2 (2), EXP.B1 (1), EXP.B2 (2), EXP.C1 (1), EXP.C2 (2); also elsewhere on the board
VCC: C40.+, C41.+, EXP.A3 (3), EXP.A32 (32), EXP.B3 (3), EXP.B32 (32), EXP.C3 (3), EXP.C32 (32); also elsewhere on the board

Notes on the sheet:
(2) Pins *TPA and *TPC are not bussed. They are locally connected to each card's corresponding
test pins (A17 & C17) to serve as test points.
(1) This pin is connected to a bus bar for power distribution, but the CFT does not (yet) require it.
It's likely to be connected to another voltage level like +3.3V for easier interfacing. Reserved for now.
(3) Reserved for future expansion
Expansion Bus (computer bus)
(2)
(1)
(3)
(4) Cheaper, 64-pin A+C row DIN41662 Type C plugs may be used for most expansion cards.
(4)
(5) !IRQ! is provided for systems which lack an interrupt controller (!IRQ0-7!)
PCB @ (0, 1.95)
CFT Mini-Computer
(5)
@(0.15, 3.675)
@(0.15, 0.25)
@(5.775, 0.25)
@(5.775, 3.675)

Board: 2 copper layers, 160.3 x 100.0 mm, 100 parts (37 on the bottom side), 156 nets.

Other parts of the board:
U$1: SIGNATURESILK; SIGNATURE

## Commit log (part)

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2021-03-29 Remove T34 from MBU read enables
2021-04-02 Draw 6U×160mm board
2021-04-02 Route board0
2021-04-03 Route board 0
2021-04-04 Update tests for new MBU
2021-04-04 Add R to DFP base
2021-04-04 Fix mnemonic in comment
2021-04-04 Refactor tests for new MBU
2021-04-04 Add missing name to bitmap instructions
2021-04-04 Add builtins from latest microcode revision
2021-04-30 Cleaning up board
2021-05-01 Fine tune board0
2021-05-02 ERC/DRC board 0, route, fine-tune
2021-05-03 Work on Board 0 schematics
2021-05-03 Fine-tune Board 0
2021-05-03 Work around MBU IBus not driving bits 15-8 (for testing)
2021-05-03 Fine-tune board0
2021-05-04 Add NCT and ECT context-management instructions
2021-05-04 Add NCT and ECT instructions
2021-05-04 Bring decoding filters in sync with microcode
2021-05-04 Update tests for current MBU
2021-05-04 Update flag unit for latest design
2021-05-04 Clean up silkscreen
2021-05-04 Re-add holes and logos
2021-05-06 Move to explicit constant store names for clarity
2021-05-06 Fix tests for new MBU
2021-05-06 Improve text fields
2021-05-06 Annotate board
2021-05-06 Documenting PCB
2021-05-08 Reimplement NCT so it (probably) works
2021-05-08 Change erroneous use of NCT to SCT
2021-05-09 Change NCT broken instruction to NMB
2021-05-09 Add MBU address decoder
2021-05-09 Change NCT instruction to NMB
2021-05-09 Fix minor issues and rebuild
2021-05-09 Drive high IBUS when CTX is read too
2021-05-09 Fix serious issue with definition of '157 MUX
2021-05-09 Add missing pull-down resistors
2021-05-09 Rename 74x257 pins
2021-05-09 Add missing pull-downs
2021-05-09 Add testbench for '257
2021-05-09 Swap ISR and TRAP vectors
2021-05-09 Fix test scripts
2021-05-10 Fix microcode bug in WAIT
2021-05-10 Remove high IBUS drive during CTX reads
2021-05-10 Move AB8-15 on peripheral connector
2021-05-10 Fix interrupt tests
2021-05-11 Add test for validity of UOP, IFL and IFV opcodes
2021-05-11 Fix IFL and IFV opcodes
2021-05-12 Improve DIP footprints
2021-05-12 Clean up schematics
2021-05-12 Clean up board
2021-05-12 Review board before printing
2021-05-12 Rearrange sheet numbers, prepare for layout
2021-05-13 Renumber schematics, start of board layout
2021-05-13 Add ALU GALs
2021-05-13 Layout board 1
2021-05-13 Work on board 1
2021-05-13 Route board 1
2021-05-17 Schematic and routing work
2021-05-17 PLD rework, tests
2021-05-17 Readd IRC bus interface sheet
2021-05-18 Work on Board1 schematics and PCB
2021-05-18 Print out chip pinout after successful PLD build
2021-05-18 Make CLRV and SETV assert on READ-ALY-U and add ALU-OE output
2021-05-20 Drop CXO & 16 MHz driver Vcc, add series resistors
2021-05-20 Use stashed version of PCB
2021-05-20 Work on board1
2021-05-28 Move pins around for ease of routing
2021-05-28 Add shift/rotate unit control GAL
2021-05-28 Add open 2-pad solder jumper
2021-05-29 Add two additional toggle input pins for toggles when AC wraps around
2021-05-29 Move to GAL for IRC decoding
2021-05-29 Add IRC decode GAL
2021-05-29 Fix IRC schematics and route Board 1
2021-05-29 Rename 16V8 to indicate pins 12 & 19 are output only
2021-06-06 Fine-tune board 1
2021-06-13 Update control unit with new MBR
2021-06-14 Finish adding new MBU to emulator.
2021-06-14 Move designators off vias.
2021-06-14 Update 16V8 symbol
2021-06-14 Add ISR/IER LEDs, route board
2021-06-19 Fine-tuning Board 1
2021-06-19 Fix IC alignment
2021-06-21 Move MEM board out of the way
2021-06-22 Start MEM board schematic, clean up old files
2021-06-22 Add MEM decoder PLD
2021-06-22 Add DIP32 package
2021-06-22 Improve SOJ36 land patterns for hand soldering
2021-06-22 Work on MEM schematics and board
2021-06-22 Add DIP32 footprints
2021-06-22 Route MEM board
2021-06-24 Fine-tune MEM board
2021-06-25 Inhihit the SRU on halt
2021-06-27 Move backplane project out of the way
2021-06-27 Copy board0 to backplane
2021-06-28 Add DIN backplane
2021-06-28 Work on DIN backplane
2021-06-28 Add single slot sheet
2021-06-28 Add 3D model
2021-06-28 Work on boards
2021-07-01 Work on backplane
2021-07-05 Move IRQS signal.
2021-07-05 Use project-wide library
2021-07-05 Fix AS6C4008-55PCN symbol
2021-07-05 Work on backplane bus hold
2021-07-11 Work on 2021 DFP
2021-07-11 Move IRQS signal
2021-07-11 Renumber ICs
2021-07-11 Add 16V8
2021-07-11 Modify DFP to accept Arduino Mega 2560, place and route
2021-07-11 Add Arduino Mega 2560
2021-07-11 Make silkscreen outline bolder
2021-07-11 Move signals around
2021-07-11 Move pins on peripheral connector pinout to allow for 12V supply
2021-07-11 Fine-tune pod board
2021-07-11 Shuffle peripheral pinout to allow for 12V
2021-07-13 Remove POWEROK from unbussed pinout
2021-07-14 Work on the DFP board
2021-07-14 Mark no-connect pins
2021-07-16 Add 8-resistor resistor pack symbol
2021-07-16 Work on DFP
2021-07-16 Simplify and lay out DFP
2021-07-17 Add new footprints
2021-07-17 Add DFP GALs
2021-07-17 Fix 3D model positions
2021-07-17 Add DFP peripheral decoding
2021-07-18 Add DIP resistor pack
2021-07-18 Add new 8-bit pod sub-schematic
2021-07-19 Added FPOExx decoders
2021-07-19 Add decoder GALs and route signals.
2021-07-20 Route DFP board
2021-07-21 Route DFP
2021-07-21 Remove FPRESET signal
2021-08-02 Rework pinout
2021-08-03 Rework pinout of DFP run-stop GAL
2021-08-05 Rearrange front panel modules, add MFD2 and AB/DB to panel v.11
2021-08-05 Assign signals to GALs
2021-08-05 Wire DFP for front panel version 11
2021-08-06 Adjusted pinout of FPOE D gal
2021-08-08 Semi-automate FP OE GAL equations and regenerate
2021-08-08 Fix syntax error
2021-08-08 Make DFP optional
2021-08-08 Add fake bus-hold to LMB instruction
2021-08-08 Update tests for emulator and verilog
2021-08-10 Shuffle pinout to ease routing
2021-08-10 Fix one semantics comment
2021-08-12 Routing DFP board
2021-08-12 Adjust whitepace
2021-08-12 Routing
2021-08-13 Work on DFP silkscreen
2021-08-14 Fine-tune DFP board
2021-08-14 Update to current HW implementation
2021-08-14 Fix RTC detect pattern
2021-08-14 Refill copper pours
2021-08-14 Fine-tuning DFP board
2021-08-15 Fine-tuning DFP board, add signal conditioning, fix minor bugs
2021-08-15 Fix device name case
2021-08-15 Simplify DFP enable equations
2021-08-15 Fix DRC/ERC bugs
2021-08-15 Restructure schematics, fix major I/O pod bug
2021-08-15 Fix DFP pod issues
2021-08-16 Fine-tune DFP board and schematics
2021-08-16 Clean up DFP project files
2021-08-17 Start merge of SRI and TIC boards
2021-08-17 Clean up DFP
2021-08-17 Add RTC model
2021-08-21 Restore file deleted by mistake
2021-08-21 Renamed
2021-08-21 Renamed edge connector to bus connector
2021-08-21 Fine tuning DFP board
2021-08-21 TIC board
2021-08-22 Added SWAB instruction
2021-08-22 Add SWAB instruction
2021-08-26 Split backplanesl; route processor backplane
2021-08-26 Clarify comment
2021-08-26 Work on DFP and TTY boards
2021-08-26 Remove silkscreen boxes from 0805 footprints
2021-08-26 Work on Processor Backplane
2021-08-27 Complete Processor Backplane, push to fabrication
2021-08-27 Copy processor backplane to peripheral backplane
2021-08-27 Work on Peripheral Backplane
2021-08-28 Add 10 and 12-way CUI pluggable terminal blocks
2021-08-28 Improve DIN 41612 jack silkscreen
2021-08-28 Separate processor and peripheral slot sheets
2021-08-28 Improve silkscreen
2021-08-29 Update footprints, check board artwork, fine tune
2021-08-29 Fine-tune PB0
2021-08-29 Add ST16C554 quad UART
2021-08-29 Move IDE emulation back
2021-08-29 Start porting IDE driver
2021-08-30 Fine-tune PB0 and PB1 boards
2021-09-04 Continue IDE emulator porting work
2021-09-10 Switch to CLK1
2021-09-12 Clean-up IDE driver
2021-09-12 Work on new TIC board
2021-09-14 Move capacitors to make space for subrack rail
2021-09-15 Fine tune board
2021-09-15 Fix bugs, prepare for manufacture
2021-09-18 Add v11 front panel (1 inch taller)
2021-09-19 Clean up gerber outputs
2021-09-19 Prepare processor and peripheral backplane r2134
2021-09-19 Work on TIC schematics
2021-09-19 Rearrange pins on STC16C554, add FL232FL
2021-09-19 Produce revision 2134 for peripheral backplane
2021-09-19 Prepare PB0 r2119 gerbers
2021-09-19 Minor changes to the DFP board pre-fabrication
2021-09-22 Port UART emulation
2021-09-23 Move pre-2019 ROM out of the way for porting
2021-09-23 Move here for historical interest
2021-09-23 Add the very basics for a blank ROM
2021-09-23 Added basic ROM compilation
2021-09-23 Add PLCC68 socket
2021-09-23 Fix eDIP socket 3D
2021-09-23 Fix pinout of STC16C554 and USB6B1
2021-09-23 Work on TIC board
2021-09-23 Minor changes
2021-09-23 Add trivial hello world ROM.
2021-09-23 Add proper TTY support to early DEB
2021-09-24 Fix CLI bug in TRAP instruction
2021-09-24 Add DEB character-level output & colourise TTY output.
2021-09-25 Make autoindex register names more human-friendly
2021-09-25 Fix state output bug; add TRACE output level
2021-09-26 Fix character buffering issue
2021-09-26 Improve readability of instruction tracing
2021-09-26 Add putud subroutine
2021-09-26 Fix bug with negative values, add bound checking
2021-09-26 Add putud routine, start porting generic macros
2021-09-28 Add memcpy and lmemcpy routines
2021-09-29 Move library files to lib/
2021-09-29 Move hardware device files to dev/
2021-10-09 C1503 silkscreen overlaps pads
2021-10-10 Change location of dfp2.asm
2021-10-10 Add script to regenerate BOM
2021-10-10 Will try 74HC74, can't source AC family in DIP
2021-10-11 Fix file dependency for new asm/ tree
2021-10-11 Add putd routine
2021-10-11 Add puth subroutine
2021-10-11 Test out puth
2021-10-11 Mark RN1702 as optional
2021-10-11 Add character literals to cftasm
2021-10-11 Start cleaning up macros
2021-10-23 Remove OE pin from upc-gate
2021-10-24 Rearrange pins for easire routing
2021-10-24 Move DFP I/O decoding to PLDs
2021-10-24 Move pod decoding to PLDs and reroute. Various other fixes
2021-10-24 Add memcpm.asm
2021-10-25 Prepare for Gerber plots
2021-10-26 Plot DFP PCB (rev 2133a) and create order
2021-10-27 Fix INH decoding bug
2021-10-27 Clean up signal names and equations
2021-10-27 Change IDEN to IDXEN
2021-10-27 Add script to generate TL866 test vectors for CFT GALs (temporary location)
2021-10-27 Change permissions
2021-10-28 Improve GAL testing and fix various bugs
2021-10-29 Symlinked to working version of galasm
2021-10-29 Adjust code for Mega 2560, mark unported code
2021-10-29 Ignore minicom text capture files (.cap)
2021-10-29 Registered new submodules
2021-10-29 Port DFP firmware to 2560
2021-10-30 Port driver_dfp to new MCU.
2021-10-30 Fix TTYD location
2021-10-31 Port to Atmega 2560
2021-10-31 Document FPuSTEP erratum
2021-10-31 Fix pin allocation erratum
2021-11-01 Correct table of ALU operations
2021-11-01 Fix signatures/filenames of DP decoder GALs
2021-11-01 Fix spelling error
2021-11-01 Add lost comment for unused RADDR 01110.
2021-11-01 Fix bug where 16-bit values have a ':' prepended
2021-11-01 Add unit-level granularity to detection and diags
2021-11-01 Update pod description
2021-11-02 Update DFP BOM
2021-11-06 Change to UTF-8 DFP terminal
2021-11-06 Fix LED definitions, add banner
2021-11-07 Implement per-unit detection status
2021-11-07 Local changes while testing hardware
2021-11-07 Fix DFP detection logic
2021-11-07 Fix DFP board detection
2021-11-08 Add DFP pod detection
2021-11-08 Work on firmware
2021-11-15 Add bus extender boards
2021-11-17 Route bus extended board
2021-11-18 Add test vectors for dfb-io-X GALs and fix numerous errors
2021-11-18 Add test vectors for dfp-fpoeX GALs
2021-11-19 Add SRAM module adaptor
2021-11-20 Fix IC values that changed due to Kicad bug
2021-11-21 Fix silkscreen error
2021-11-21 Enable bus before reading DFP peripherals
2022-02-21 Add missing newline
2022-02-21 Resolve bus contention issue
2022-02-25 Fix twin PLD bug and PLD *testing* bug causing DFP-IO-A to misbehave
2022-02-26 Update BOM for Board 1
2022-02-28 Switch from XMEM to GPIO for bus operations to respect chip setup times
2022-03-03 Re-enable all pod tests
